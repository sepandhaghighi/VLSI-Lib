* HSPICE Timing Acquisition
* Liberty NCX vC-2009.06-SP1
* Build(Jul 16 2009)
* Filename: /home/mrezaie/Downloads/ncx_inv/lib_all/and2/tOut_B_0001r/tOut_B_0001r.sp

* combinational Rise
* Driver Waveform Type: snps_predriver
* Pin Name: Out
* Related Input Pin: B
* Input Waveform: Rise
* input_threshold_pct_rise: 50.00
* output_threshold_pct_rise: 50.00
* input_threshold_pct_fall: 50.00
* output_threshold_pct_fall: 50.00
* slew_lower_threshold_pct_rise: 25.00
* slew_upper_threshold_pct_rise: 75.00
* slew_lower_threshold_pct_fall: 25.00
* slew_upper_threshold_pct_fall: 75.00
* capacitance_lower_threshold_pct_rise: 0.50
* capacitance_upper_threshold_pct_rise: 75.00
* capacitance_lower_threshold_pct_fall: 25.00
* capacitance_upper_threshold_pct_fall: 99.50
* slew_derate_from_library: 1.00
* Clock Width(ps): 4000.000000

* Pin Signal Voltage Level:
* Pin A:		 H=1.200000	 L=0.000000
* Pin B:		 H=1.200000	 L=0.000000
* Pin Out:		 H=1.200000	 L=0.000000

* Lib Slew Index(ps): 6.000000 12.000000 24.000000 50.000000 100.000000 200.000000 400.000000 800.000000
* Input Transition Time(ps): 6.000000 12.000000 24.000000 50.000000 100.000000 200.000000 400.000000 800.000000
* Lib Load Index(ff): 6.000000 9.000000 12.000000 15.000000 18.000000 21.000000 24.000000 27.000000 30.000000 33.000000 36.000000 40.000000 42.000000
* TEMPERATURE ==========================
.TEMP 2.500000e+01

* MODELS ===============================
.prot
.inc '/home/mrezaie/Desktop/hspice.mdl'
.unprot
.option brief

* CELL SUBCKT ==========================
.inc '/home/mrezaie/Downloads/ncx_inv/work/netlists/and2.spc'

* OPTIONS ==============================
* NCX Default Options:
.OPTIONS POST=1 PROBE POST_VERSION=2001
+ INGOLD=2 NOMOD NOPAGE NUMDGT=10 MEASDGT=10
+ LIMPTS=500000 ICSWEEP=0 AUTOSTOP ALTCC=1
+ RUNLVL=5 ACCURATE=1
+ ABSVAR=1.000000e-03 RELVAR=1.000000e-02
* (ACCURATE=1 sets these control options: LVLtim=3 DVDT=2 RELVAR=0.2 ABSVAR=0.2 FT=0.2 RELMOS=0.01)
* (ACCURATE=0 uses default control options: LVLtim=1 DVDT=4 RELVAR=0.3 ABSVAR=0.5 FT=0.25 RELMOS=0.05)
* End of NCX Default Options.

* Lib Level Options:
* No Lib Level Options Here
* Cell Level Options:
* No Cell Level Options Here
* Pin Level Options:
* No Pin Level Options Here
* Arc Level Options:
* No Arc Level Options Here

* VOLTAGE SOURCES ======================
.GLOBAL VSS Vdd
Vn_VSS VSS 0 DC 0.000000e+00
Vn_Vdd Vdd 0 DC 1.200000e+00

* ACQUISITION CIRCUIT ==================
X_and2 n_a n_b n_out and2
Vn_A n_A n_A2 DC 0
Vn_B n_B n_B2 DC 0
Vn_Out n_Out n_Out1 DC 0
CLD_Out n_Out1 0 cap_Out
.PROBE TRAN V(n_Out1)
.PARAM SideCap = 2.4000000000e-14

* PROBE ================================
.PROBE TRAN V(n_Out) I(Vn_Out) V(n_A) I(Vn_A) V(n_B) I(Vn_B) I(Vn_VSS) I(Vn_Vdd)

* STIMULI ==============================
* InPin A PWL length=2
* InPin B PWL length=16
* Sensitization Template Name: and2_wave_0_3
* SensInputs= A: 	1
* SensInputs= B: 	01
* SensOuputs= Out: 	01

* nc_td: Measurement Starting time
* adrv_cap: Active Driver Output Load
* iptr: Input Transition Time
* cap_PIN: Relative Output Pin Load
.DATA stimdata
index nc_td adrv_cap iptr cap_Out
+ t_A0 v_A0 t_A1 v_A1
+ t_B0 v_B0 t_B1 v_B1 t_B2 v_B2 t_B3 v_B3 t_B4 v_B4 t_B5 v_B5 t_B6 v_B6 t_B7 v_B7 t_B8 v_B8 t_B9 v_B9
+ t_B10 v_B10 t_B11 v_B11 t_B12 v_B12 t_B13 v_B13 t_B14 v_B14 t_B15 v_B15
* Input Slew Index= 6.0000000000e-12 (IPTR = 6.0000000000e-12) ======================================================================
* Waveform to Side Pin A (Full swing = 1.000000e-11):
* 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00
* Stimlus to RelatedInPin B (Slew Index = 6.000000e-12, Slew = 6.000000e-12, Full swing = 1.200000e-11):
* 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00 4.0112000000e-09 6.0000000000e-02 4.0124000000e-09 2.1774457168e-01
* 4.0136000000e-09 3.7681869307e-01 4.0148000000e-09 5.1634960800e-01 4.0160000000e-09 6.4019237886e-01 4.0172000000e-09 7.5144162445e-01 4.0184000000e-09 8.5258152389e-01
* 4.0196000000e-09 9.4560623102e-01 4.0208000000e-09 1.0321165360e+00 4.0220000000e-09 1.1133974596e+00 4.0232000000e-09 1.1904805415e+00 4.0244000000e-09 1.2000000000e+00
* 4.0256000000e-09 1.2000000000e+00
* Input Slew Index = 6.000000e-12, IPTR = 6.000000e-12, Output Load = 6.000000e-15 *************************************
  1 4.0100000000e-09 5.0000000000e-12 6.0000000000e-12 6.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0112000000e-09 6.0000000000e-02 4.0124000000e-09 2.1774457168e-01 4.0136000000e-09 3.7681869307e-01 4.0148000000e-09 5.1634960800e-01 4.0160000000e-09 6.4019237886e-01
+ 4.0172000000e-09 7.5144162445e-01 4.0184000000e-09 8.5258152389e-01 4.0196000000e-09 9.4560623102e-01 4.0208000000e-09 1.0321165360e+00 4.0220000000e-09 1.1133974596e+00
+ 4.0232000000e-09 1.1904805415e+00 4.0244000000e-09 1.2000000000e+00 4.0256000000e-09 1.2000000000e+00
* Input Slew Index = 6.000000e-12, IPTR = 6.000000e-12, Output Load = 9.000000e-15 *************************************
  2 4.0100000000e-09 5.0000000000e-12 6.0000000000e-12 9.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0112000000e-09 6.0000000000e-02 4.0124000000e-09 2.1774457168e-01 4.0136000000e-09 3.7681869307e-01 4.0148000000e-09 5.1634960800e-01 4.0160000000e-09 6.4019237886e-01
+ 4.0172000000e-09 7.5144162445e-01 4.0184000000e-09 8.5258152389e-01 4.0196000000e-09 9.4560623102e-01 4.0208000000e-09 1.0321165360e+00 4.0220000000e-09 1.1133974596e+00
+ 4.0232000000e-09 1.1904805415e+00 4.0244000000e-09 1.2000000000e+00 4.0256000000e-09 1.2000000000e+00
* Input Slew Index = 6.000000e-12, IPTR = 6.000000e-12, Output Load = 1.200000e-14 *************************************
  3 4.0100000000e-09 5.0000000000e-12 6.0000000000e-12 1.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0112000000e-09 6.0000000000e-02 4.0124000000e-09 2.1774457168e-01 4.0136000000e-09 3.7681869307e-01 4.0148000000e-09 5.1634960800e-01 4.0160000000e-09 6.4019237886e-01
+ 4.0172000000e-09 7.5144162445e-01 4.0184000000e-09 8.5258152389e-01 4.0196000000e-09 9.4560623102e-01 4.0208000000e-09 1.0321165360e+00 4.0220000000e-09 1.1133974596e+00
+ 4.0232000000e-09 1.1904805415e+00 4.0244000000e-09 1.2000000000e+00 4.0256000000e-09 1.2000000000e+00
* Input Slew Index = 6.000000e-12, IPTR = 6.000000e-12, Output Load = 1.500000e-14 *************************************
  4 4.0100000000e-09 5.0000000000e-12 6.0000000000e-12 1.5000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0112000000e-09 6.0000000000e-02 4.0124000000e-09 2.1774457168e-01 4.0136000000e-09 3.7681869307e-01 4.0148000000e-09 5.1634960800e-01 4.0160000000e-09 6.4019237886e-01
+ 4.0172000000e-09 7.5144162445e-01 4.0184000000e-09 8.5258152389e-01 4.0196000000e-09 9.4560623102e-01 4.0208000000e-09 1.0321165360e+00 4.0220000000e-09 1.1133974596e+00
+ 4.0232000000e-09 1.1904805415e+00 4.0244000000e-09 1.2000000000e+00 4.0256000000e-09 1.2000000000e+00
* Input Slew Index = 6.000000e-12, IPTR = 6.000000e-12, Output Load = 1.800000e-14 *************************************
  5 4.0100000000e-09 5.0000000000e-12 6.0000000000e-12 1.8000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0112000000e-09 6.0000000000e-02 4.0124000000e-09 2.1774457168e-01 4.0136000000e-09 3.7681869307e-01 4.0148000000e-09 5.1634960800e-01 4.0160000000e-09 6.4019237886e-01
+ 4.0172000000e-09 7.5144162445e-01 4.0184000000e-09 8.5258152389e-01 4.0196000000e-09 9.4560623102e-01 4.0208000000e-09 1.0321165360e+00 4.0220000000e-09 1.1133974596e+00
+ 4.0232000000e-09 1.1904805415e+00 4.0244000000e-09 1.2000000000e+00 4.0256000000e-09 1.2000000000e+00
* Input Slew Index = 6.000000e-12, IPTR = 6.000000e-12, Output Load = 2.100000e-14 *************************************
  6 4.0100000000e-09 5.0000000000e-12 6.0000000000e-12 2.1000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0112000000e-09 6.0000000000e-02 4.0124000000e-09 2.1774457168e-01 4.0136000000e-09 3.7681869307e-01 4.0148000000e-09 5.1634960800e-01 4.0160000000e-09 6.4019237886e-01
+ 4.0172000000e-09 7.5144162445e-01 4.0184000000e-09 8.5258152389e-01 4.0196000000e-09 9.4560623102e-01 4.0208000000e-09 1.0321165360e+00 4.0220000000e-09 1.1133974596e+00
+ 4.0232000000e-09 1.1904805415e+00 4.0244000000e-09 1.2000000000e+00 4.0256000000e-09 1.2000000000e+00
* Input Slew Index = 6.000000e-12, IPTR = 6.000000e-12, Output Load = 2.400000e-14 *************************************
  7 4.0100000000e-09 5.0000000000e-12 6.0000000000e-12 2.4000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0112000000e-09 6.0000000000e-02 4.0124000000e-09 2.1774457168e-01 4.0136000000e-09 3.7681869307e-01 4.0148000000e-09 5.1634960800e-01 4.0160000000e-09 6.4019237886e-01
+ 4.0172000000e-09 7.5144162445e-01 4.0184000000e-09 8.5258152389e-01 4.0196000000e-09 9.4560623102e-01 4.0208000000e-09 1.0321165360e+00 4.0220000000e-09 1.1133974596e+00
+ 4.0232000000e-09 1.1904805415e+00 4.0244000000e-09 1.2000000000e+00 4.0256000000e-09 1.2000000000e+00
* Input Slew Index = 6.000000e-12, IPTR = 6.000000e-12, Output Load = 2.700000e-14 *************************************
  8 4.0100000000e-09 5.0000000000e-12 6.0000000000e-12 2.7000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0112000000e-09 6.0000000000e-02 4.0124000000e-09 2.1774457168e-01 4.0136000000e-09 3.7681869307e-01 4.0148000000e-09 5.1634960800e-01 4.0160000000e-09 6.4019237886e-01
+ 4.0172000000e-09 7.5144162445e-01 4.0184000000e-09 8.5258152389e-01 4.0196000000e-09 9.4560623102e-01 4.0208000000e-09 1.0321165360e+00 4.0220000000e-09 1.1133974596e+00
+ 4.0232000000e-09 1.1904805415e+00 4.0244000000e-09 1.2000000000e+00 4.0256000000e-09 1.2000000000e+00
* Input Slew Index = 6.000000e-12, IPTR = 6.000000e-12, Output Load = 3.000000e-14 *************************************
  9 4.0100000000e-09 5.0000000000e-12 6.0000000000e-12 3.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0112000000e-09 6.0000000000e-02 4.0124000000e-09 2.1774457168e-01 4.0136000000e-09 3.7681869307e-01 4.0148000000e-09 5.1634960800e-01 4.0160000000e-09 6.4019237886e-01
+ 4.0172000000e-09 7.5144162445e-01 4.0184000000e-09 8.5258152389e-01 4.0196000000e-09 9.4560623102e-01 4.0208000000e-09 1.0321165360e+00 4.0220000000e-09 1.1133974596e+00
+ 4.0232000000e-09 1.1904805415e+00 4.0244000000e-09 1.2000000000e+00 4.0256000000e-09 1.2000000000e+00
* Input Slew Index = 6.000000e-12, IPTR = 6.000000e-12, Output Load = 3.300000e-14 *************************************
 10 4.0100000000e-09 5.0000000000e-12 6.0000000000e-12 3.3000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0112000000e-09 6.0000000000e-02 4.0124000000e-09 2.1774457168e-01 4.0136000000e-09 3.7681869307e-01 4.0148000000e-09 5.1634960800e-01 4.0160000000e-09 6.4019237886e-01
+ 4.0172000000e-09 7.5144162445e-01 4.0184000000e-09 8.5258152389e-01 4.0196000000e-09 9.4560623102e-01 4.0208000000e-09 1.0321165360e+00 4.0220000000e-09 1.1133974596e+00
+ 4.0232000000e-09 1.1904805415e+00 4.0244000000e-09 1.2000000000e+00 4.0256000000e-09 1.2000000000e+00
* Input Slew Index = 6.000000e-12, IPTR = 6.000000e-12, Output Load = 3.600000e-14 *************************************
 11 4.0100000000e-09 5.0000000000e-12 6.0000000000e-12 3.6000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0112000000e-09 6.0000000000e-02 4.0124000000e-09 2.1774457168e-01 4.0136000000e-09 3.7681869307e-01 4.0148000000e-09 5.1634960800e-01 4.0160000000e-09 6.4019237886e-01
+ 4.0172000000e-09 7.5144162445e-01 4.0184000000e-09 8.5258152389e-01 4.0196000000e-09 9.4560623102e-01 4.0208000000e-09 1.0321165360e+00 4.0220000000e-09 1.1133974596e+00
+ 4.0232000000e-09 1.1904805415e+00 4.0244000000e-09 1.2000000000e+00 4.0256000000e-09 1.2000000000e+00
* Input Slew Index = 6.000000e-12, IPTR = 6.000000e-12, Output Load = 4.000000e-14 *************************************
 12 4.0100000000e-09 5.0000000000e-12 6.0000000000e-12 4.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0112000000e-09 6.0000000000e-02 4.0124000000e-09 2.1774457168e-01 4.0136000000e-09 3.7681869307e-01 4.0148000000e-09 5.1634960800e-01 4.0160000000e-09 6.4019237886e-01
+ 4.0172000000e-09 7.5144162445e-01 4.0184000000e-09 8.5258152389e-01 4.0196000000e-09 9.4560623102e-01 4.0208000000e-09 1.0321165360e+00 4.0220000000e-09 1.1133974596e+00
+ 4.0232000000e-09 1.1904805415e+00 4.0244000000e-09 1.2000000000e+00 4.0256000000e-09 1.2000000000e+00
* Input Slew Index = 6.000000e-12, IPTR = 6.000000e-12, Output Load = 4.200000e-14 *************************************
 13 4.0100000000e-09 5.0000000000e-12 6.0000000000e-12 4.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0112000000e-09 6.0000000000e-02 4.0124000000e-09 2.1774457168e-01 4.0136000000e-09 3.7681869307e-01 4.0148000000e-09 5.1634960800e-01 4.0160000000e-09 6.4019237886e-01
+ 4.0172000000e-09 7.5144162445e-01 4.0184000000e-09 8.5258152389e-01 4.0196000000e-09 9.4560623102e-01 4.0208000000e-09 1.0321165360e+00 4.0220000000e-09 1.1133974596e+00
+ 4.0232000000e-09 1.1904805415e+00 4.0244000000e-09 1.2000000000e+00 4.0256000000e-09 1.2000000000e+00
* Input Slew Index= 1.2000000000e-11 (IPTR = 1.2000000000e-11) ======================================================================
* Waveform to Side Pin A (Full swing = 1.000000e-11):
* 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00
* Stimlus to RelatedInPin B (Slew Index = 1.200000e-11, Slew = 1.200000e-11, Full swing = 2.400000e-11):
* 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00 4.0124000000e-09 6.0000000000e-02 4.0148000000e-09 2.1774457168e-01
* 4.0172000000e-09 3.7681869307e-01 4.0196000000e-09 5.1634960800e-01 4.0220000000e-09 6.4019237886e-01 4.0244000000e-09 7.5144162445e-01 4.0268000000e-09 8.5258152389e-01
* 4.0292000000e-09 9.4560623102e-01 4.0316000000e-09 1.0321165360e+00 4.0340000000e-09 1.1133974596e+00 4.0364000000e-09 1.1904805415e+00 4.0388000000e-09 1.2000000000e+00
* 4.0412000000e-09 1.2000000000e+00
* Input Slew Index = 1.200000e-11, IPTR = 1.200000e-11, Output Load = 6.000000e-15 *************************************
 14 4.0100000000e-09 5.0000000000e-12 1.2000000000e-11 6.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0124000000e-09 6.0000000000e-02 4.0148000000e-09 2.1774457168e-01 4.0172000000e-09 3.7681869307e-01 4.0196000000e-09 5.1634960800e-01 4.0220000000e-09 6.4019237886e-01
+ 4.0244000000e-09 7.5144162445e-01 4.0268000000e-09 8.5258152389e-01 4.0292000000e-09 9.4560623102e-01 4.0316000000e-09 1.0321165360e+00 4.0340000000e-09 1.1133974596e+00
+ 4.0364000000e-09 1.1904805415e+00 4.0388000000e-09 1.2000000000e+00 4.0412000000e-09 1.2000000000e+00
* Input Slew Index = 1.200000e-11, IPTR = 1.200000e-11, Output Load = 9.000000e-15 *************************************
 15 4.0100000000e-09 5.0000000000e-12 1.2000000000e-11 9.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0124000000e-09 6.0000000000e-02 4.0148000000e-09 2.1774457168e-01 4.0172000000e-09 3.7681869307e-01 4.0196000000e-09 5.1634960800e-01 4.0220000000e-09 6.4019237886e-01
+ 4.0244000000e-09 7.5144162445e-01 4.0268000000e-09 8.5258152389e-01 4.0292000000e-09 9.4560623102e-01 4.0316000000e-09 1.0321165360e+00 4.0340000000e-09 1.1133974596e+00
+ 4.0364000000e-09 1.1904805415e+00 4.0388000000e-09 1.2000000000e+00 4.0412000000e-09 1.2000000000e+00
* Input Slew Index = 1.200000e-11, IPTR = 1.200000e-11, Output Load = 1.200000e-14 *************************************
 16 4.0100000000e-09 5.0000000000e-12 1.2000000000e-11 1.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0124000000e-09 6.0000000000e-02 4.0148000000e-09 2.1774457168e-01 4.0172000000e-09 3.7681869307e-01 4.0196000000e-09 5.1634960800e-01 4.0220000000e-09 6.4019237886e-01
+ 4.0244000000e-09 7.5144162445e-01 4.0268000000e-09 8.5258152389e-01 4.0292000000e-09 9.4560623102e-01 4.0316000000e-09 1.0321165360e+00 4.0340000000e-09 1.1133974596e+00
+ 4.0364000000e-09 1.1904805415e+00 4.0388000000e-09 1.2000000000e+00 4.0412000000e-09 1.2000000000e+00
* Input Slew Index = 1.200000e-11, IPTR = 1.200000e-11, Output Load = 1.500000e-14 *************************************
 17 4.0100000000e-09 5.0000000000e-12 1.2000000000e-11 1.5000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0124000000e-09 6.0000000000e-02 4.0148000000e-09 2.1774457168e-01 4.0172000000e-09 3.7681869307e-01 4.0196000000e-09 5.1634960800e-01 4.0220000000e-09 6.4019237886e-01
+ 4.0244000000e-09 7.5144162445e-01 4.0268000000e-09 8.5258152389e-01 4.0292000000e-09 9.4560623102e-01 4.0316000000e-09 1.0321165360e+00 4.0340000000e-09 1.1133974596e+00
+ 4.0364000000e-09 1.1904805415e+00 4.0388000000e-09 1.2000000000e+00 4.0412000000e-09 1.2000000000e+00
* Input Slew Index = 1.200000e-11, IPTR = 1.200000e-11, Output Load = 1.800000e-14 *************************************
 18 4.0100000000e-09 5.0000000000e-12 1.2000000000e-11 1.8000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0124000000e-09 6.0000000000e-02 4.0148000000e-09 2.1774457168e-01 4.0172000000e-09 3.7681869307e-01 4.0196000000e-09 5.1634960800e-01 4.0220000000e-09 6.4019237886e-01
+ 4.0244000000e-09 7.5144162445e-01 4.0268000000e-09 8.5258152389e-01 4.0292000000e-09 9.4560623102e-01 4.0316000000e-09 1.0321165360e+00 4.0340000000e-09 1.1133974596e+00
+ 4.0364000000e-09 1.1904805415e+00 4.0388000000e-09 1.2000000000e+00 4.0412000000e-09 1.2000000000e+00
* Input Slew Index = 1.200000e-11, IPTR = 1.200000e-11, Output Load = 2.100000e-14 *************************************
 19 4.0100000000e-09 5.0000000000e-12 1.2000000000e-11 2.1000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0124000000e-09 6.0000000000e-02 4.0148000000e-09 2.1774457168e-01 4.0172000000e-09 3.7681869307e-01 4.0196000000e-09 5.1634960800e-01 4.0220000000e-09 6.4019237886e-01
+ 4.0244000000e-09 7.5144162445e-01 4.0268000000e-09 8.5258152389e-01 4.0292000000e-09 9.4560623102e-01 4.0316000000e-09 1.0321165360e+00 4.0340000000e-09 1.1133974596e+00
+ 4.0364000000e-09 1.1904805415e+00 4.0388000000e-09 1.2000000000e+00 4.0412000000e-09 1.2000000000e+00
* Input Slew Index = 1.200000e-11, IPTR = 1.200000e-11, Output Load = 2.400000e-14 *************************************
 20 4.0100000000e-09 5.0000000000e-12 1.2000000000e-11 2.4000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0124000000e-09 6.0000000000e-02 4.0148000000e-09 2.1774457168e-01 4.0172000000e-09 3.7681869307e-01 4.0196000000e-09 5.1634960800e-01 4.0220000000e-09 6.4019237886e-01
+ 4.0244000000e-09 7.5144162445e-01 4.0268000000e-09 8.5258152389e-01 4.0292000000e-09 9.4560623102e-01 4.0316000000e-09 1.0321165360e+00 4.0340000000e-09 1.1133974596e+00
+ 4.0364000000e-09 1.1904805415e+00 4.0388000000e-09 1.2000000000e+00 4.0412000000e-09 1.2000000000e+00
* Input Slew Index = 1.200000e-11, IPTR = 1.200000e-11, Output Load = 2.700000e-14 *************************************
 21 4.0100000000e-09 5.0000000000e-12 1.2000000000e-11 2.7000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0124000000e-09 6.0000000000e-02 4.0148000000e-09 2.1774457168e-01 4.0172000000e-09 3.7681869307e-01 4.0196000000e-09 5.1634960800e-01 4.0220000000e-09 6.4019237886e-01
+ 4.0244000000e-09 7.5144162445e-01 4.0268000000e-09 8.5258152389e-01 4.0292000000e-09 9.4560623102e-01 4.0316000000e-09 1.0321165360e+00 4.0340000000e-09 1.1133974596e+00
+ 4.0364000000e-09 1.1904805415e+00 4.0388000000e-09 1.2000000000e+00 4.0412000000e-09 1.2000000000e+00
* Input Slew Index = 1.200000e-11, IPTR = 1.200000e-11, Output Load = 3.000000e-14 *************************************
 22 4.0100000000e-09 5.0000000000e-12 1.2000000000e-11 3.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0124000000e-09 6.0000000000e-02 4.0148000000e-09 2.1774457168e-01 4.0172000000e-09 3.7681869307e-01 4.0196000000e-09 5.1634960800e-01 4.0220000000e-09 6.4019237886e-01
+ 4.0244000000e-09 7.5144162445e-01 4.0268000000e-09 8.5258152389e-01 4.0292000000e-09 9.4560623102e-01 4.0316000000e-09 1.0321165360e+00 4.0340000000e-09 1.1133974596e+00
+ 4.0364000000e-09 1.1904805415e+00 4.0388000000e-09 1.2000000000e+00 4.0412000000e-09 1.2000000000e+00
* Input Slew Index = 1.200000e-11, IPTR = 1.200000e-11, Output Load = 3.300000e-14 *************************************
 23 4.0100000000e-09 5.0000000000e-12 1.2000000000e-11 3.3000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0124000000e-09 6.0000000000e-02 4.0148000000e-09 2.1774457168e-01 4.0172000000e-09 3.7681869307e-01 4.0196000000e-09 5.1634960800e-01 4.0220000000e-09 6.4019237886e-01
+ 4.0244000000e-09 7.5144162445e-01 4.0268000000e-09 8.5258152389e-01 4.0292000000e-09 9.4560623102e-01 4.0316000000e-09 1.0321165360e+00 4.0340000000e-09 1.1133974596e+00
+ 4.0364000000e-09 1.1904805415e+00 4.0388000000e-09 1.2000000000e+00 4.0412000000e-09 1.2000000000e+00
* Input Slew Index = 1.200000e-11, IPTR = 1.200000e-11, Output Load = 3.600000e-14 *************************************
 24 4.0100000000e-09 5.0000000000e-12 1.2000000000e-11 3.6000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0124000000e-09 6.0000000000e-02 4.0148000000e-09 2.1774457168e-01 4.0172000000e-09 3.7681869307e-01 4.0196000000e-09 5.1634960800e-01 4.0220000000e-09 6.4019237886e-01
+ 4.0244000000e-09 7.5144162445e-01 4.0268000000e-09 8.5258152389e-01 4.0292000000e-09 9.4560623102e-01 4.0316000000e-09 1.0321165360e+00 4.0340000000e-09 1.1133974596e+00
+ 4.0364000000e-09 1.1904805415e+00 4.0388000000e-09 1.2000000000e+00 4.0412000000e-09 1.2000000000e+00
* Input Slew Index = 1.200000e-11, IPTR = 1.200000e-11, Output Load = 4.000000e-14 *************************************
 25 4.0100000000e-09 5.0000000000e-12 1.2000000000e-11 4.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0124000000e-09 6.0000000000e-02 4.0148000000e-09 2.1774457168e-01 4.0172000000e-09 3.7681869307e-01 4.0196000000e-09 5.1634960800e-01 4.0220000000e-09 6.4019237886e-01
+ 4.0244000000e-09 7.5144162445e-01 4.0268000000e-09 8.5258152389e-01 4.0292000000e-09 9.4560623102e-01 4.0316000000e-09 1.0321165360e+00 4.0340000000e-09 1.1133974596e+00
+ 4.0364000000e-09 1.1904805415e+00 4.0388000000e-09 1.2000000000e+00 4.0412000000e-09 1.2000000000e+00
* Input Slew Index = 1.200000e-11, IPTR = 1.200000e-11, Output Load = 4.200000e-14 *************************************
 26 4.0100000000e-09 5.0000000000e-12 1.2000000000e-11 4.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0124000000e-09 6.0000000000e-02 4.0148000000e-09 2.1774457168e-01 4.0172000000e-09 3.7681869307e-01 4.0196000000e-09 5.1634960800e-01 4.0220000000e-09 6.4019237886e-01
+ 4.0244000000e-09 7.5144162445e-01 4.0268000000e-09 8.5258152389e-01 4.0292000000e-09 9.4560623102e-01 4.0316000000e-09 1.0321165360e+00 4.0340000000e-09 1.1133974596e+00
+ 4.0364000000e-09 1.1904805415e+00 4.0388000000e-09 1.2000000000e+00 4.0412000000e-09 1.2000000000e+00
* Input Slew Index= 2.4000000000e-11 (IPTR = 2.4000000000e-11) ======================================================================
* Waveform to Side Pin A (Full swing = 1.000000e-11):
* 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00
* Stimlus to RelatedInPin B (Slew Index = 2.400000e-11, Slew = 2.400000e-11, Full swing = 4.800000e-11):
* 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00 4.0148000000e-09 6.0000000000e-02 4.0196000000e-09 2.1774457168e-01
* 4.0244000000e-09 3.7681869307e-01 4.0292000000e-09 5.1634960800e-01 4.0340000000e-09 6.4019237886e-01 4.0388000000e-09 7.5144162445e-01 4.0436000000e-09 8.5258152389e-01
* 4.0484000000e-09 9.4560623102e-01 4.0532000000e-09 1.0321165360e+00 4.0580000000e-09 1.1133974596e+00 4.0628000000e-09 1.1904805415e+00 4.0676000000e-09 1.2000000000e+00
* 4.0724000000e-09 1.2000000000e+00
* Input Slew Index = 2.400000e-11, IPTR = 2.400000e-11, Output Load = 6.000000e-15 *************************************
 27 4.0100000000e-09 5.0000000000e-12 2.4000000000e-11 6.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0148000000e-09 6.0000000000e-02 4.0196000000e-09 2.1774457168e-01 4.0244000000e-09 3.7681869307e-01 4.0292000000e-09 5.1634960800e-01 4.0340000000e-09 6.4019237886e-01
+ 4.0388000000e-09 7.5144162445e-01 4.0436000000e-09 8.5258152389e-01 4.0484000000e-09 9.4560623102e-01 4.0532000000e-09 1.0321165360e+00 4.0580000000e-09 1.1133974596e+00
+ 4.0628000000e-09 1.1904805415e+00 4.0676000000e-09 1.2000000000e+00 4.0724000000e-09 1.2000000000e+00
* Input Slew Index = 2.400000e-11, IPTR = 2.400000e-11, Output Load = 9.000000e-15 *************************************
 28 4.0100000000e-09 5.0000000000e-12 2.4000000000e-11 9.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0148000000e-09 6.0000000000e-02 4.0196000000e-09 2.1774457168e-01 4.0244000000e-09 3.7681869307e-01 4.0292000000e-09 5.1634960800e-01 4.0340000000e-09 6.4019237886e-01
+ 4.0388000000e-09 7.5144162445e-01 4.0436000000e-09 8.5258152389e-01 4.0484000000e-09 9.4560623102e-01 4.0532000000e-09 1.0321165360e+00 4.0580000000e-09 1.1133974596e+00
+ 4.0628000000e-09 1.1904805415e+00 4.0676000000e-09 1.2000000000e+00 4.0724000000e-09 1.2000000000e+00
* Input Slew Index = 2.400000e-11, IPTR = 2.400000e-11, Output Load = 1.200000e-14 *************************************
 29 4.0100000000e-09 5.0000000000e-12 2.4000000000e-11 1.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0148000000e-09 6.0000000000e-02 4.0196000000e-09 2.1774457168e-01 4.0244000000e-09 3.7681869307e-01 4.0292000000e-09 5.1634960800e-01 4.0340000000e-09 6.4019237886e-01
+ 4.0388000000e-09 7.5144162445e-01 4.0436000000e-09 8.5258152389e-01 4.0484000000e-09 9.4560623102e-01 4.0532000000e-09 1.0321165360e+00 4.0580000000e-09 1.1133974596e+00
+ 4.0628000000e-09 1.1904805415e+00 4.0676000000e-09 1.2000000000e+00 4.0724000000e-09 1.2000000000e+00
* Input Slew Index = 2.400000e-11, IPTR = 2.400000e-11, Output Load = 1.500000e-14 *************************************
 30 4.0100000000e-09 5.0000000000e-12 2.4000000000e-11 1.5000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0148000000e-09 6.0000000000e-02 4.0196000000e-09 2.1774457168e-01 4.0244000000e-09 3.7681869307e-01 4.0292000000e-09 5.1634960800e-01 4.0340000000e-09 6.4019237886e-01
+ 4.0388000000e-09 7.5144162445e-01 4.0436000000e-09 8.5258152389e-01 4.0484000000e-09 9.4560623102e-01 4.0532000000e-09 1.0321165360e+00 4.0580000000e-09 1.1133974596e+00
+ 4.0628000000e-09 1.1904805415e+00 4.0676000000e-09 1.2000000000e+00 4.0724000000e-09 1.2000000000e+00
* Input Slew Index = 2.400000e-11, IPTR = 2.400000e-11, Output Load = 1.800000e-14 *************************************
 31 4.0100000000e-09 5.0000000000e-12 2.4000000000e-11 1.8000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0148000000e-09 6.0000000000e-02 4.0196000000e-09 2.1774457168e-01 4.0244000000e-09 3.7681869307e-01 4.0292000000e-09 5.1634960800e-01 4.0340000000e-09 6.4019237886e-01
+ 4.0388000000e-09 7.5144162445e-01 4.0436000000e-09 8.5258152389e-01 4.0484000000e-09 9.4560623102e-01 4.0532000000e-09 1.0321165360e+00 4.0580000000e-09 1.1133974596e+00
+ 4.0628000000e-09 1.1904805415e+00 4.0676000000e-09 1.2000000000e+00 4.0724000000e-09 1.2000000000e+00
* Input Slew Index = 2.400000e-11, IPTR = 2.400000e-11, Output Load = 2.100000e-14 *************************************
 32 4.0100000000e-09 5.0000000000e-12 2.4000000000e-11 2.1000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0148000000e-09 6.0000000000e-02 4.0196000000e-09 2.1774457168e-01 4.0244000000e-09 3.7681869307e-01 4.0292000000e-09 5.1634960800e-01 4.0340000000e-09 6.4019237886e-01
+ 4.0388000000e-09 7.5144162445e-01 4.0436000000e-09 8.5258152389e-01 4.0484000000e-09 9.4560623102e-01 4.0532000000e-09 1.0321165360e+00 4.0580000000e-09 1.1133974596e+00
+ 4.0628000000e-09 1.1904805415e+00 4.0676000000e-09 1.2000000000e+00 4.0724000000e-09 1.2000000000e+00
* Input Slew Index = 2.400000e-11, IPTR = 2.400000e-11, Output Load = 2.400000e-14 *************************************
 33 4.0100000000e-09 5.0000000000e-12 2.4000000000e-11 2.4000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0148000000e-09 6.0000000000e-02 4.0196000000e-09 2.1774457168e-01 4.0244000000e-09 3.7681869307e-01 4.0292000000e-09 5.1634960800e-01 4.0340000000e-09 6.4019237886e-01
+ 4.0388000000e-09 7.5144162445e-01 4.0436000000e-09 8.5258152389e-01 4.0484000000e-09 9.4560623102e-01 4.0532000000e-09 1.0321165360e+00 4.0580000000e-09 1.1133974596e+00
+ 4.0628000000e-09 1.1904805415e+00 4.0676000000e-09 1.2000000000e+00 4.0724000000e-09 1.2000000000e+00
* Input Slew Index = 2.400000e-11, IPTR = 2.400000e-11, Output Load = 2.700000e-14 *************************************
 34 4.0100000000e-09 5.0000000000e-12 2.4000000000e-11 2.7000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0148000000e-09 6.0000000000e-02 4.0196000000e-09 2.1774457168e-01 4.0244000000e-09 3.7681869307e-01 4.0292000000e-09 5.1634960800e-01 4.0340000000e-09 6.4019237886e-01
+ 4.0388000000e-09 7.5144162445e-01 4.0436000000e-09 8.5258152389e-01 4.0484000000e-09 9.4560623102e-01 4.0532000000e-09 1.0321165360e+00 4.0580000000e-09 1.1133974596e+00
+ 4.0628000000e-09 1.1904805415e+00 4.0676000000e-09 1.2000000000e+00 4.0724000000e-09 1.2000000000e+00
* Input Slew Index = 2.400000e-11, IPTR = 2.400000e-11, Output Load = 3.000000e-14 *************************************
 35 4.0100000000e-09 5.0000000000e-12 2.4000000000e-11 3.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0148000000e-09 6.0000000000e-02 4.0196000000e-09 2.1774457168e-01 4.0244000000e-09 3.7681869307e-01 4.0292000000e-09 5.1634960800e-01 4.0340000000e-09 6.4019237886e-01
+ 4.0388000000e-09 7.5144162445e-01 4.0436000000e-09 8.5258152389e-01 4.0484000000e-09 9.4560623102e-01 4.0532000000e-09 1.0321165360e+00 4.0580000000e-09 1.1133974596e+00
+ 4.0628000000e-09 1.1904805415e+00 4.0676000000e-09 1.2000000000e+00 4.0724000000e-09 1.2000000000e+00
* Input Slew Index = 2.400000e-11, IPTR = 2.400000e-11, Output Load = 3.300000e-14 *************************************
 36 4.0100000000e-09 5.0000000000e-12 2.4000000000e-11 3.3000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0148000000e-09 6.0000000000e-02 4.0196000000e-09 2.1774457168e-01 4.0244000000e-09 3.7681869307e-01 4.0292000000e-09 5.1634960800e-01 4.0340000000e-09 6.4019237886e-01
+ 4.0388000000e-09 7.5144162445e-01 4.0436000000e-09 8.5258152389e-01 4.0484000000e-09 9.4560623102e-01 4.0532000000e-09 1.0321165360e+00 4.0580000000e-09 1.1133974596e+00
+ 4.0628000000e-09 1.1904805415e+00 4.0676000000e-09 1.2000000000e+00 4.0724000000e-09 1.2000000000e+00
* Input Slew Index = 2.400000e-11, IPTR = 2.400000e-11, Output Load = 3.600000e-14 *************************************
 37 4.0100000000e-09 5.0000000000e-12 2.4000000000e-11 3.6000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0148000000e-09 6.0000000000e-02 4.0196000000e-09 2.1774457168e-01 4.0244000000e-09 3.7681869307e-01 4.0292000000e-09 5.1634960800e-01 4.0340000000e-09 6.4019237886e-01
+ 4.0388000000e-09 7.5144162445e-01 4.0436000000e-09 8.5258152389e-01 4.0484000000e-09 9.4560623102e-01 4.0532000000e-09 1.0321165360e+00 4.0580000000e-09 1.1133974596e+00
+ 4.0628000000e-09 1.1904805415e+00 4.0676000000e-09 1.2000000000e+00 4.0724000000e-09 1.2000000000e+00
* Input Slew Index = 2.400000e-11, IPTR = 2.400000e-11, Output Load = 4.000000e-14 *************************************
 38 4.0100000000e-09 5.0000000000e-12 2.4000000000e-11 4.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0148000000e-09 6.0000000000e-02 4.0196000000e-09 2.1774457168e-01 4.0244000000e-09 3.7681869307e-01 4.0292000000e-09 5.1634960800e-01 4.0340000000e-09 6.4019237886e-01
+ 4.0388000000e-09 7.5144162445e-01 4.0436000000e-09 8.5258152389e-01 4.0484000000e-09 9.4560623102e-01 4.0532000000e-09 1.0321165360e+00 4.0580000000e-09 1.1133974596e+00
+ 4.0628000000e-09 1.1904805415e+00 4.0676000000e-09 1.2000000000e+00 4.0724000000e-09 1.2000000000e+00
* Input Slew Index = 2.400000e-11, IPTR = 2.400000e-11, Output Load = 4.200000e-14 *************************************
 39 4.0100000000e-09 5.0000000000e-12 2.4000000000e-11 4.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0148000000e-09 6.0000000000e-02 4.0196000000e-09 2.1774457168e-01 4.0244000000e-09 3.7681869307e-01 4.0292000000e-09 5.1634960800e-01 4.0340000000e-09 6.4019237886e-01
+ 4.0388000000e-09 7.5144162445e-01 4.0436000000e-09 8.5258152389e-01 4.0484000000e-09 9.4560623102e-01 4.0532000000e-09 1.0321165360e+00 4.0580000000e-09 1.1133974596e+00
+ 4.0628000000e-09 1.1904805415e+00 4.0676000000e-09 1.2000000000e+00 4.0724000000e-09 1.2000000000e+00
* Input Slew Index= 5.0000000000e-11 (IPTR = 5.0000000000e-11) ======================================================================
* Waveform to Side Pin A (Full swing = 1.000000e-11):
* 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00
* Stimlus to RelatedInPin B (Slew Index = 5.000000e-11, Slew = 5.000000e-11, Full swing = 1.000000e-10):
* 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00 4.0200000000e-09 6.0000000000e-02 4.0300000000e-09 2.1774457168e-01
* 4.0400000000e-09 3.7681869307e-01 4.0500000000e-09 5.1634960800e-01 4.0600000000e-09 6.4019237886e-01 4.0700000000e-09 7.5144162445e-01 4.0800000000e-09 8.5258152389e-01
* 4.0900000000e-09 9.4560623102e-01 4.1000000000e-09 1.0321165360e+00 4.1100000000e-09 1.1133974596e+00 4.1200000000e-09 1.1904805415e+00 4.1300000000e-09 1.2000000000e+00
* 4.1400000000e-09 1.2000000000e+00
* Input Slew Index = 5.000000e-11, IPTR = 5.000000e-11, Output Load = 6.000000e-15 *************************************
 40 4.0100000000e-09 5.0000000000e-12 5.0000000000e-11 6.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0200000000e-09 6.0000000000e-02 4.0300000000e-09 2.1774457168e-01 4.0400000000e-09 3.7681869307e-01 4.0500000000e-09 5.1634960800e-01 4.0600000000e-09 6.4019237886e-01
+ 4.0700000000e-09 7.5144162445e-01 4.0800000000e-09 8.5258152389e-01 4.0900000000e-09 9.4560623102e-01 4.1000000000e-09 1.0321165360e+00 4.1100000000e-09 1.1133974596e+00
+ 4.1200000000e-09 1.1904805415e+00 4.1300000000e-09 1.2000000000e+00 4.1400000000e-09 1.2000000000e+00
* Input Slew Index = 5.000000e-11, IPTR = 5.000000e-11, Output Load = 9.000000e-15 *************************************
 41 4.0100000000e-09 5.0000000000e-12 5.0000000000e-11 9.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0200000000e-09 6.0000000000e-02 4.0300000000e-09 2.1774457168e-01 4.0400000000e-09 3.7681869307e-01 4.0500000000e-09 5.1634960800e-01 4.0600000000e-09 6.4019237886e-01
+ 4.0700000000e-09 7.5144162445e-01 4.0800000000e-09 8.5258152389e-01 4.0900000000e-09 9.4560623102e-01 4.1000000000e-09 1.0321165360e+00 4.1100000000e-09 1.1133974596e+00
+ 4.1200000000e-09 1.1904805415e+00 4.1300000000e-09 1.2000000000e+00 4.1400000000e-09 1.2000000000e+00
* Input Slew Index = 5.000000e-11, IPTR = 5.000000e-11, Output Load = 1.200000e-14 *************************************
 42 4.0100000000e-09 5.0000000000e-12 5.0000000000e-11 1.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0200000000e-09 6.0000000000e-02 4.0300000000e-09 2.1774457168e-01 4.0400000000e-09 3.7681869307e-01 4.0500000000e-09 5.1634960800e-01 4.0600000000e-09 6.4019237886e-01
+ 4.0700000000e-09 7.5144162445e-01 4.0800000000e-09 8.5258152389e-01 4.0900000000e-09 9.4560623102e-01 4.1000000000e-09 1.0321165360e+00 4.1100000000e-09 1.1133974596e+00
+ 4.1200000000e-09 1.1904805415e+00 4.1300000000e-09 1.2000000000e+00 4.1400000000e-09 1.2000000000e+00
* Input Slew Index = 5.000000e-11, IPTR = 5.000000e-11, Output Load = 1.500000e-14 *************************************
 43 4.0100000000e-09 5.0000000000e-12 5.0000000000e-11 1.5000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0200000000e-09 6.0000000000e-02 4.0300000000e-09 2.1774457168e-01 4.0400000000e-09 3.7681869307e-01 4.0500000000e-09 5.1634960800e-01 4.0600000000e-09 6.4019237886e-01
+ 4.0700000000e-09 7.5144162445e-01 4.0800000000e-09 8.5258152389e-01 4.0900000000e-09 9.4560623102e-01 4.1000000000e-09 1.0321165360e+00 4.1100000000e-09 1.1133974596e+00
+ 4.1200000000e-09 1.1904805415e+00 4.1300000000e-09 1.2000000000e+00 4.1400000000e-09 1.2000000000e+00
* Input Slew Index = 5.000000e-11, IPTR = 5.000000e-11, Output Load = 1.800000e-14 *************************************
 44 4.0100000000e-09 5.0000000000e-12 5.0000000000e-11 1.8000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0200000000e-09 6.0000000000e-02 4.0300000000e-09 2.1774457168e-01 4.0400000000e-09 3.7681869307e-01 4.0500000000e-09 5.1634960800e-01 4.0600000000e-09 6.4019237886e-01
+ 4.0700000000e-09 7.5144162445e-01 4.0800000000e-09 8.5258152389e-01 4.0900000000e-09 9.4560623102e-01 4.1000000000e-09 1.0321165360e+00 4.1100000000e-09 1.1133974596e+00
+ 4.1200000000e-09 1.1904805415e+00 4.1300000000e-09 1.2000000000e+00 4.1400000000e-09 1.2000000000e+00
* Input Slew Index = 5.000000e-11, IPTR = 5.000000e-11, Output Load = 2.100000e-14 *************************************
 45 4.0100000000e-09 5.0000000000e-12 5.0000000000e-11 2.1000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0200000000e-09 6.0000000000e-02 4.0300000000e-09 2.1774457168e-01 4.0400000000e-09 3.7681869307e-01 4.0500000000e-09 5.1634960800e-01 4.0600000000e-09 6.4019237886e-01
+ 4.0700000000e-09 7.5144162445e-01 4.0800000000e-09 8.5258152389e-01 4.0900000000e-09 9.4560623102e-01 4.1000000000e-09 1.0321165360e+00 4.1100000000e-09 1.1133974596e+00
+ 4.1200000000e-09 1.1904805415e+00 4.1300000000e-09 1.2000000000e+00 4.1400000000e-09 1.2000000000e+00
* Input Slew Index = 5.000000e-11, IPTR = 5.000000e-11, Output Load = 2.400000e-14 *************************************
 46 4.0100000000e-09 5.0000000000e-12 5.0000000000e-11 2.4000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0200000000e-09 6.0000000000e-02 4.0300000000e-09 2.1774457168e-01 4.0400000000e-09 3.7681869307e-01 4.0500000000e-09 5.1634960800e-01 4.0600000000e-09 6.4019237886e-01
+ 4.0700000000e-09 7.5144162445e-01 4.0800000000e-09 8.5258152389e-01 4.0900000000e-09 9.4560623102e-01 4.1000000000e-09 1.0321165360e+00 4.1100000000e-09 1.1133974596e+00
+ 4.1200000000e-09 1.1904805415e+00 4.1300000000e-09 1.2000000000e+00 4.1400000000e-09 1.2000000000e+00
* Input Slew Index = 5.000000e-11, IPTR = 5.000000e-11, Output Load = 2.700000e-14 *************************************
 47 4.0100000000e-09 5.0000000000e-12 5.0000000000e-11 2.7000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0200000000e-09 6.0000000000e-02 4.0300000000e-09 2.1774457168e-01 4.0400000000e-09 3.7681869307e-01 4.0500000000e-09 5.1634960800e-01 4.0600000000e-09 6.4019237886e-01
+ 4.0700000000e-09 7.5144162445e-01 4.0800000000e-09 8.5258152389e-01 4.0900000000e-09 9.4560623102e-01 4.1000000000e-09 1.0321165360e+00 4.1100000000e-09 1.1133974596e+00
+ 4.1200000000e-09 1.1904805415e+00 4.1300000000e-09 1.2000000000e+00 4.1400000000e-09 1.2000000000e+00
* Input Slew Index = 5.000000e-11, IPTR = 5.000000e-11, Output Load = 3.000000e-14 *************************************
 48 4.0100000000e-09 5.0000000000e-12 5.0000000000e-11 3.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0200000000e-09 6.0000000000e-02 4.0300000000e-09 2.1774457168e-01 4.0400000000e-09 3.7681869307e-01 4.0500000000e-09 5.1634960800e-01 4.0600000000e-09 6.4019237886e-01
+ 4.0700000000e-09 7.5144162445e-01 4.0800000000e-09 8.5258152389e-01 4.0900000000e-09 9.4560623102e-01 4.1000000000e-09 1.0321165360e+00 4.1100000000e-09 1.1133974596e+00
+ 4.1200000000e-09 1.1904805415e+00 4.1300000000e-09 1.2000000000e+00 4.1400000000e-09 1.2000000000e+00
* Input Slew Index = 5.000000e-11, IPTR = 5.000000e-11, Output Load = 3.300000e-14 *************************************
 49 4.0100000000e-09 5.0000000000e-12 5.0000000000e-11 3.3000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0200000000e-09 6.0000000000e-02 4.0300000000e-09 2.1774457168e-01 4.0400000000e-09 3.7681869307e-01 4.0500000000e-09 5.1634960800e-01 4.0600000000e-09 6.4019237886e-01
+ 4.0700000000e-09 7.5144162445e-01 4.0800000000e-09 8.5258152389e-01 4.0900000000e-09 9.4560623102e-01 4.1000000000e-09 1.0321165360e+00 4.1100000000e-09 1.1133974596e+00
+ 4.1200000000e-09 1.1904805415e+00 4.1300000000e-09 1.2000000000e+00 4.1400000000e-09 1.2000000000e+00
* Input Slew Index = 5.000000e-11, IPTR = 5.000000e-11, Output Load = 3.600000e-14 *************************************
 50 4.0100000000e-09 5.0000000000e-12 5.0000000000e-11 3.6000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0200000000e-09 6.0000000000e-02 4.0300000000e-09 2.1774457168e-01 4.0400000000e-09 3.7681869307e-01 4.0500000000e-09 5.1634960800e-01 4.0600000000e-09 6.4019237886e-01
+ 4.0700000000e-09 7.5144162445e-01 4.0800000000e-09 8.5258152389e-01 4.0900000000e-09 9.4560623102e-01 4.1000000000e-09 1.0321165360e+00 4.1100000000e-09 1.1133974596e+00
+ 4.1200000000e-09 1.1904805415e+00 4.1300000000e-09 1.2000000000e+00 4.1400000000e-09 1.2000000000e+00
* Input Slew Index = 5.000000e-11, IPTR = 5.000000e-11, Output Load = 4.000000e-14 *************************************
 51 4.0100000000e-09 5.0000000000e-12 5.0000000000e-11 4.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0200000000e-09 6.0000000000e-02 4.0300000000e-09 2.1774457168e-01 4.0400000000e-09 3.7681869307e-01 4.0500000000e-09 5.1634960800e-01 4.0600000000e-09 6.4019237886e-01
+ 4.0700000000e-09 7.5144162445e-01 4.0800000000e-09 8.5258152389e-01 4.0900000000e-09 9.4560623102e-01 4.1000000000e-09 1.0321165360e+00 4.1100000000e-09 1.1133974596e+00
+ 4.1200000000e-09 1.1904805415e+00 4.1300000000e-09 1.2000000000e+00 4.1400000000e-09 1.2000000000e+00
* Input Slew Index = 5.000000e-11, IPTR = 5.000000e-11, Output Load = 4.200000e-14 *************************************
 52 4.0100000000e-09 5.0000000000e-12 5.0000000000e-11 4.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0200000000e-09 6.0000000000e-02 4.0300000000e-09 2.1774457168e-01 4.0400000000e-09 3.7681869307e-01 4.0500000000e-09 5.1634960800e-01 4.0600000000e-09 6.4019237886e-01
+ 4.0700000000e-09 7.5144162445e-01 4.0800000000e-09 8.5258152389e-01 4.0900000000e-09 9.4560623102e-01 4.1000000000e-09 1.0321165360e+00 4.1100000000e-09 1.1133974596e+00
+ 4.1200000000e-09 1.1904805415e+00 4.1300000000e-09 1.2000000000e+00 4.1400000000e-09 1.2000000000e+00
* Input Slew Index= 1.0000000000e-10 (IPTR = 1.0000000000e-10) ======================================================================
* Waveform to Side Pin A (Full swing = 1.000000e-11):
* 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00
* Stimlus to RelatedInPin B (Slew Index = 1.000000e-10, Slew = 1.000000e-10, Full swing = 2.000000e-10):
* 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00 4.0300000000e-09 6.0000000000e-02 4.0500000000e-09 2.1774457168e-01
* 4.0700000000e-09 3.7681869307e-01 4.0900000000e-09 5.1634960800e-01 4.1100000000e-09 6.4019237886e-01 4.1300000000e-09 7.5144162445e-01 4.1500000000e-09 8.5258152389e-01
* 4.1700000000e-09 9.4560623102e-01 4.1900000000e-09 1.0321165360e+00 4.2100000000e-09 1.1133974596e+00 4.2300000000e-09 1.1904805415e+00 4.2500000000e-09 1.2000000000e+00
* 4.2700000000e-09 1.2000000000e+00
* Input Slew Index = 1.000000e-10, IPTR = 1.000000e-10, Output Load = 6.000000e-15 *************************************
 53 4.0100000000e-09 5.0000000000e-12 1.0000000000e-10 6.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0300000000e-09 6.0000000000e-02 4.0500000000e-09 2.1774457168e-01 4.0700000000e-09 3.7681869307e-01 4.0900000000e-09 5.1634960800e-01 4.1100000000e-09 6.4019237886e-01
+ 4.1300000000e-09 7.5144162445e-01 4.1500000000e-09 8.5258152389e-01 4.1700000000e-09 9.4560623102e-01 4.1900000000e-09 1.0321165360e+00 4.2100000000e-09 1.1133974596e+00
+ 4.2300000000e-09 1.1904805415e+00 4.2500000000e-09 1.2000000000e+00 4.2700000000e-09 1.2000000000e+00
* Input Slew Index = 1.000000e-10, IPTR = 1.000000e-10, Output Load = 9.000000e-15 *************************************
 54 4.0100000000e-09 5.0000000000e-12 1.0000000000e-10 9.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0300000000e-09 6.0000000000e-02 4.0500000000e-09 2.1774457168e-01 4.0700000000e-09 3.7681869307e-01 4.0900000000e-09 5.1634960800e-01 4.1100000000e-09 6.4019237886e-01
+ 4.1300000000e-09 7.5144162445e-01 4.1500000000e-09 8.5258152389e-01 4.1700000000e-09 9.4560623102e-01 4.1900000000e-09 1.0321165360e+00 4.2100000000e-09 1.1133974596e+00
+ 4.2300000000e-09 1.1904805415e+00 4.2500000000e-09 1.2000000000e+00 4.2700000000e-09 1.2000000000e+00
* Input Slew Index = 1.000000e-10, IPTR = 1.000000e-10, Output Load = 1.200000e-14 *************************************
 55 4.0100000000e-09 5.0000000000e-12 1.0000000000e-10 1.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0300000000e-09 6.0000000000e-02 4.0500000000e-09 2.1774457168e-01 4.0700000000e-09 3.7681869307e-01 4.0900000000e-09 5.1634960800e-01 4.1100000000e-09 6.4019237886e-01
+ 4.1300000000e-09 7.5144162445e-01 4.1500000000e-09 8.5258152389e-01 4.1700000000e-09 9.4560623102e-01 4.1900000000e-09 1.0321165360e+00 4.2100000000e-09 1.1133974596e+00
+ 4.2300000000e-09 1.1904805415e+00 4.2500000000e-09 1.2000000000e+00 4.2700000000e-09 1.2000000000e+00
* Input Slew Index = 1.000000e-10, IPTR = 1.000000e-10, Output Load = 1.500000e-14 *************************************
 56 4.0100000000e-09 5.0000000000e-12 1.0000000000e-10 1.5000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0300000000e-09 6.0000000000e-02 4.0500000000e-09 2.1774457168e-01 4.0700000000e-09 3.7681869307e-01 4.0900000000e-09 5.1634960800e-01 4.1100000000e-09 6.4019237886e-01
+ 4.1300000000e-09 7.5144162445e-01 4.1500000000e-09 8.5258152389e-01 4.1700000000e-09 9.4560623102e-01 4.1900000000e-09 1.0321165360e+00 4.2100000000e-09 1.1133974596e+00
+ 4.2300000000e-09 1.1904805415e+00 4.2500000000e-09 1.2000000000e+00 4.2700000000e-09 1.2000000000e+00
* Input Slew Index = 1.000000e-10, IPTR = 1.000000e-10, Output Load = 1.800000e-14 *************************************
 57 4.0100000000e-09 5.0000000000e-12 1.0000000000e-10 1.8000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0300000000e-09 6.0000000000e-02 4.0500000000e-09 2.1774457168e-01 4.0700000000e-09 3.7681869307e-01 4.0900000000e-09 5.1634960800e-01 4.1100000000e-09 6.4019237886e-01
+ 4.1300000000e-09 7.5144162445e-01 4.1500000000e-09 8.5258152389e-01 4.1700000000e-09 9.4560623102e-01 4.1900000000e-09 1.0321165360e+00 4.2100000000e-09 1.1133974596e+00
+ 4.2300000000e-09 1.1904805415e+00 4.2500000000e-09 1.2000000000e+00 4.2700000000e-09 1.2000000000e+00
* Input Slew Index = 1.000000e-10, IPTR = 1.000000e-10, Output Load = 2.100000e-14 *************************************
 58 4.0100000000e-09 5.0000000000e-12 1.0000000000e-10 2.1000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0300000000e-09 6.0000000000e-02 4.0500000000e-09 2.1774457168e-01 4.0700000000e-09 3.7681869307e-01 4.0900000000e-09 5.1634960800e-01 4.1100000000e-09 6.4019237886e-01
+ 4.1300000000e-09 7.5144162445e-01 4.1500000000e-09 8.5258152389e-01 4.1700000000e-09 9.4560623102e-01 4.1900000000e-09 1.0321165360e+00 4.2100000000e-09 1.1133974596e+00
+ 4.2300000000e-09 1.1904805415e+00 4.2500000000e-09 1.2000000000e+00 4.2700000000e-09 1.2000000000e+00
* Input Slew Index = 1.000000e-10, IPTR = 1.000000e-10, Output Load = 2.400000e-14 *************************************
 59 4.0100000000e-09 5.0000000000e-12 1.0000000000e-10 2.4000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0300000000e-09 6.0000000000e-02 4.0500000000e-09 2.1774457168e-01 4.0700000000e-09 3.7681869307e-01 4.0900000000e-09 5.1634960800e-01 4.1100000000e-09 6.4019237886e-01
+ 4.1300000000e-09 7.5144162445e-01 4.1500000000e-09 8.5258152389e-01 4.1700000000e-09 9.4560623102e-01 4.1900000000e-09 1.0321165360e+00 4.2100000000e-09 1.1133974596e+00
+ 4.2300000000e-09 1.1904805415e+00 4.2500000000e-09 1.2000000000e+00 4.2700000000e-09 1.2000000000e+00
* Input Slew Index = 1.000000e-10, IPTR = 1.000000e-10, Output Load = 2.700000e-14 *************************************
 60 4.0100000000e-09 5.0000000000e-12 1.0000000000e-10 2.7000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0300000000e-09 6.0000000000e-02 4.0500000000e-09 2.1774457168e-01 4.0700000000e-09 3.7681869307e-01 4.0900000000e-09 5.1634960800e-01 4.1100000000e-09 6.4019237886e-01
+ 4.1300000000e-09 7.5144162445e-01 4.1500000000e-09 8.5258152389e-01 4.1700000000e-09 9.4560623102e-01 4.1900000000e-09 1.0321165360e+00 4.2100000000e-09 1.1133974596e+00
+ 4.2300000000e-09 1.1904805415e+00 4.2500000000e-09 1.2000000000e+00 4.2700000000e-09 1.2000000000e+00
* Input Slew Index = 1.000000e-10, IPTR = 1.000000e-10, Output Load = 3.000000e-14 *************************************
 61 4.0100000000e-09 5.0000000000e-12 1.0000000000e-10 3.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0300000000e-09 6.0000000000e-02 4.0500000000e-09 2.1774457168e-01 4.0700000000e-09 3.7681869307e-01 4.0900000000e-09 5.1634960800e-01 4.1100000000e-09 6.4019237886e-01
+ 4.1300000000e-09 7.5144162445e-01 4.1500000000e-09 8.5258152389e-01 4.1700000000e-09 9.4560623102e-01 4.1900000000e-09 1.0321165360e+00 4.2100000000e-09 1.1133974596e+00
+ 4.2300000000e-09 1.1904805415e+00 4.2500000000e-09 1.2000000000e+00 4.2700000000e-09 1.2000000000e+00
* Input Slew Index = 1.000000e-10, IPTR = 1.000000e-10, Output Load = 3.300000e-14 *************************************
 62 4.0100000000e-09 5.0000000000e-12 1.0000000000e-10 3.3000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0300000000e-09 6.0000000000e-02 4.0500000000e-09 2.1774457168e-01 4.0700000000e-09 3.7681869307e-01 4.0900000000e-09 5.1634960800e-01 4.1100000000e-09 6.4019237886e-01
+ 4.1300000000e-09 7.5144162445e-01 4.1500000000e-09 8.5258152389e-01 4.1700000000e-09 9.4560623102e-01 4.1900000000e-09 1.0321165360e+00 4.2100000000e-09 1.1133974596e+00
+ 4.2300000000e-09 1.1904805415e+00 4.2500000000e-09 1.2000000000e+00 4.2700000000e-09 1.2000000000e+00
* Input Slew Index = 1.000000e-10, IPTR = 1.000000e-10, Output Load = 3.600000e-14 *************************************
 63 4.0100000000e-09 5.0000000000e-12 1.0000000000e-10 3.6000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0300000000e-09 6.0000000000e-02 4.0500000000e-09 2.1774457168e-01 4.0700000000e-09 3.7681869307e-01 4.0900000000e-09 5.1634960800e-01 4.1100000000e-09 6.4019237886e-01
+ 4.1300000000e-09 7.5144162445e-01 4.1500000000e-09 8.5258152389e-01 4.1700000000e-09 9.4560623102e-01 4.1900000000e-09 1.0321165360e+00 4.2100000000e-09 1.1133974596e+00
+ 4.2300000000e-09 1.1904805415e+00 4.2500000000e-09 1.2000000000e+00 4.2700000000e-09 1.2000000000e+00
* Input Slew Index = 1.000000e-10, IPTR = 1.000000e-10, Output Load = 4.000000e-14 *************************************
 64 4.0100000000e-09 5.0000000000e-12 1.0000000000e-10 4.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0300000000e-09 6.0000000000e-02 4.0500000000e-09 2.1774457168e-01 4.0700000000e-09 3.7681869307e-01 4.0900000000e-09 5.1634960800e-01 4.1100000000e-09 6.4019237886e-01
+ 4.1300000000e-09 7.5144162445e-01 4.1500000000e-09 8.5258152389e-01 4.1700000000e-09 9.4560623102e-01 4.1900000000e-09 1.0321165360e+00 4.2100000000e-09 1.1133974596e+00
+ 4.2300000000e-09 1.1904805415e+00 4.2500000000e-09 1.2000000000e+00 4.2700000000e-09 1.2000000000e+00
* Input Slew Index = 1.000000e-10, IPTR = 1.000000e-10, Output Load = 4.200000e-14 *************************************
 65 4.0100000000e-09 5.0000000000e-12 1.0000000000e-10 4.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0300000000e-09 6.0000000000e-02 4.0500000000e-09 2.1774457168e-01 4.0700000000e-09 3.7681869307e-01 4.0900000000e-09 5.1634960800e-01 4.1100000000e-09 6.4019237886e-01
+ 4.1300000000e-09 7.5144162445e-01 4.1500000000e-09 8.5258152389e-01 4.1700000000e-09 9.4560623102e-01 4.1900000000e-09 1.0321165360e+00 4.2100000000e-09 1.1133974596e+00
+ 4.2300000000e-09 1.1904805415e+00 4.2500000000e-09 1.2000000000e+00 4.2700000000e-09 1.2000000000e+00
* Input Slew Index= 2.0000000000e-10 (IPTR = 2.0000000000e-10) ======================================================================
* Waveform to Side Pin A (Full swing = 1.000000e-11):
* 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00
* Stimlus to RelatedInPin B (Slew Index = 2.000000e-10, Slew = 2.000000e-10, Full swing = 4.000000e-10):
* 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00 4.0500000000e-09 6.0000000000e-02 4.0900000000e-09 2.1774457168e-01
* 4.1300000000e-09 3.7681869307e-01 4.1700000000e-09 5.1634960800e-01 4.2100000000e-09 6.4019237886e-01 4.2500000000e-09 7.5144162445e-01 4.2900000000e-09 8.5258152389e-01
* 4.3300000000e-09 9.4560623102e-01 4.3700000000e-09 1.0321165360e+00 4.4100000000e-09 1.1133974596e+00 4.4500000000e-09 1.1904805415e+00 4.4900000000e-09 1.2000000000e+00
* 4.5300000000e-09 1.2000000000e+00
* Input Slew Index = 2.000000e-10, IPTR = 2.000000e-10, Output Load = 6.000000e-15 *************************************
 66 4.0100000000e-09 5.0000000000e-12 2.0000000000e-10 6.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0500000000e-09 6.0000000000e-02 4.0900000000e-09 2.1774457168e-01 4.1300000000e-09 3.7681869307e-01 4.1700000000e-09 5.1634960800e-01 4.2100000000e-09 6.4019237886e-01
+ 4.2500000000e-09 7.5144162445e-01 4.2900000000e-09 8.5258152389e-01 4.3300000000e-09 9.4560623102e-01 4.3700000000e-09 1.0321165360e+00 4.4100000000e-09 1.1133974596e+00
+ 4.4500000000e-09 1.1904805415e+00 4.4900000000e-09 1.2000000000e+00 4.5300000000e-09 1.2000000000e+00
* Input Slew Index = 2.000000e-10, IPTR = 2.000000e-10, Output Load = 9.000000e-15 *************************************
 67 4.0100000000e-09 5.0000000000e-12 2.0000000000e-10 9.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0500000000e-09 6.0000000000e-02 4.0900000000e-09 2.1774457168e-01 4.1300000000e-09 3.7681869307e-01 4.1700000000e-09 5.1634960800e-01 4.2100000000e-09 6.4019237886e-01
+ 4.2500000000e-09 7.5144162445e-01 4.2900000000e-09 8.5258152389e-01 4.3300000000e-09 9.4560623102e-01 4.3700000000e-09 1.0321165360e+00 4.4100000000e-09 1.1133974596e+00
+ 4.4500000000e-09 1.1904805415e+00 4.4900000000e-09 1.2000000000e+00 4.5300000000e-09 1.2000000000e+00
* Input Slew Index = 2.000000e-10, IPTR = 2.000000e-10, Output Load = 1.200000e-14 *************************************
 68 4.0100000000e-09 5.0000000000e-12 2.0000000000e-10 1.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0500000000e-09 6.0000000000e-02 4.0900000000e-09 2.1774457168e-01 4.1300000000e-09 3.7681869307e-01 4.1700000000e-09 5.1634960800e-01 4.2100000000e-09 6.4019237886e-01
+ 4.2500000000e-09 7.5144162445e-01 4.2900000000e-09 8.5258152389e-01 4.3300000000e-09 9.4560623102e-01 4.3700000000e-09 1.0321165360e+00 4.4100000000e-09 1.1133974596e+00
+ 4.4500000000e-09 1.1904805415e+00 4.4900000000e-09 1.2000000000e+00 4.5300000000e-09 1.2000000000e+00
* Input Slew Index = 2.000000e-10, IPTR = 2.000000e-10, Output Load = 1.500000e-14 *************************************
 69 4.0100000000e-09 5.0000000000e-12 2.0000000000e-10 1.5000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0500000000e-09 6.0000000000e-02 4.0900000000e-09 2.1774457168e-01 4.1300000000e-09 3.7681869307e-01 4.1700000000e-09 5.1634960800e-01 4.2100000000e-09 6.4019237886e-01
+ 4.2500000000e-09 7.5144162445e-01 4.2900000000e-09 8.5258152389e-01 4.3300000000e-09 9.4560623102e-01 4.3700000000e-09 1.0321165360e+00 4.4100000000e-09 1.1133974596e+00
+ 4.4500000000e-09 1.1904805415e+00 4.4900000000e-09 1.2000000000e+00 4.5300000000e-09 1.2000000000e+00
* Input Slew Index = 2.000000e-10, IPTR = 2.000000e-10, Output Load = 1.800000e-14 *************************************
 70 4.0100000000e-09 5.0000000000e-12 2.0000000000e-10 1.8000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0500000000e-09 6.0000000000e-02 4.0900000000e-09 2.1774457168e-01 4.1300000000e-09 3.7681869307e-01 4.1700000000e-09 5.1634960800e-01 4.2100000000e-09 6.4019237886e-01
+ 4.2500000000e-09 7.5144162445e-01 4.2900000000e-09 8.5258152389e-01 4.3300000000e-09 9.4560623102e-01 4.3700000000e-09 1.0321165360e+00 4.4100000000e-09 1.1133974596e+00
+ 4.4500000000e-09 1.1904805415e+00 4.4900000000e-09 1.2000000000e+00 4.5300000000e-09 1.2000000000e+00
* Input Slew Index = 2.000000e-10, IPTR = 2.000000e-10, Output Load = 2.100000e-14 *************************************
 71 4.0100000000e-09 5.0000000000e-12 2.0000000000e-10 2.1000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0500000000e-09 6.0000000000e-02 4.0900000000e-09 2.1774457168e-01 4.1300000000e-09 3.7681869307e-01 4.1700000000e-09 5.1634960800e-01 4.2100000000e-09 6.4019237886e-01
+ 4.2500000000e-09 7.5144162445e-01 4.2900000000e-09 8.5258152389e-01 4.3300000000e-09 9.4560623102e-01 4.3700000000e-09 1.0321165360e+00 4.4100000000e-09 1.1133974596e+00
+ 4.4500000000e-09 1.1904805415e+00 4.4900000000e-09 1.2000000000e+00 4.5300000000e-09 1.2000000000e+00
* Input Slew Index = 2.000000e-10, IPTR = 2.000000e-10, Output Load = 2.400000e-14 *************************************
 72 4.0100000000e-09 5.0000000000e-12 2.0000000000e-10 2.4000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0500000000e-09 6.0000000000e-02 4.0900000000e-09 2.1774457168e-01 4.1300000000e-09 3.7681869307e-01 4.1700000000e-09 5.1634960800e-01 4.2100000000e-09 6.4019237886e-01
+ 4.2500000000e-09 7.5144162445e-01 4.2900000000e-09 8.5258152389e-01 4.3300000000e-09 9.4560623102e-01 4.3700000000e-09 1.0321165360e+00 4.4100000000e-09 1.1133974596e+00
+ 4.4500000000e-09 1.1904805415e+00 4.4900000000e-09 1.2000000000e+00 4.5300000000e-09 1.2000000000e+00
* Input Slew Index = 2.000000e-10, IPTR = 2.000000e-10, Output Load = 2.700000e-14 *************************************
 73 4.0100000000e-09 5.0000000000e-12 2.0000000000e-10 2.7000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0500000000e-09 6.0000000000e-02 4.0900000000e-09 2.1774457168e-01 4.1300000000e-09 3.7681869307e-01 4.1700000000e-09 5.1634960800e-01 4.2100000000e-09 6.4019237886e-01
+ 4.2500000000e-09 7.5144162445e-01 4.2900000000e-09 8.5258152389e-01 4.3300000000e-09 9.4560623102e-01 4.3700000000e-09 1.0321165360e+00 4.4100000000e-09 1.1133974596e+00
+ 4.4500000000e-09 1.1904805415e+00 4.4900000000e-09 1.2000000000e+00 4.5300000000e-09 1.2000000000e+00
* Input Slew Index = 2.000000e-10, IPTR = 2.000000e-10, Output Load = 3.000000e-14 *************************************
 74 4.0100000000e-09 5.0000000000e-12 2.0000000000e-10 3.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0500000000e-09 6.0000000000e-02 4.0900000000e-09 2.1774457168e-01 4.1300000000e-09 3.7681869307e-01 4.1700000000e-09 5.1634960800e-01 4.2100000000e-09 6.4019237886e-01
+ 4.2500000000e-09 7.5144162445e-01 4.2900000000e-09 8.5258152389e-01 4.3300000000e-09 9.4560623102e-01 4.3700000000e-09 1.0321165360e+00 4.4100000000e-09 1.1133974596e+00
+ 4.4500000000e-09 1.1904805415e+00 4.4900000000e-09 1.2000000000e+00 4.5300000000e-09 1.2000000000e+00
* Input Slew Index = 2.000000e-10, IPTR = 2.000000e-10, Output Load = 3.300000e-14 *************************************
 75 4.0100000000e-09 5.0000000000e-12 2.0000000000e-10 3.3000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0500000000e-09 6.0000000000e-02 4.0900000000e-09 2.1774457168e-01 4.1300000000e-09 3.7681869307e-01 4.1700000000e-09 5.1634960800e-01 4.2100000000e-09 6.4019237886e-01
+ 4.2500000000e-09 7.5144162445e-01 4.2900000000e-09 8.5258152389e-01 4.3300000000e-09 9.4560623102e-01 4.3700000000e-09 1.0321165360e+00 4.4100000000e-09 1.1133974596e+00
+ 4.4500000000e-09 1.1904805415e+00 4.4900000000e-09 1.2000000000e+00 4.5300000000e-09 1.2000000000e+00
* Input Slew Index = 2.000000e-10, IPTR = 2.000000e-10, Output Load = 3.600000e-14 *************************************
 76 4.0100000000e-09 5.0000000000e-12 2.0000000000e-10 3.6000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0500000000e-09 6.0000000000e-02 4.0900000000e-09 2.1774457168e-01 4.1300000000e-09 3.7681869307e-01 4.1700000000e-09 5.1634960800e-01 4.2100000000e-09 6.4019237886e-01
+ 4.2500000000e-09 7.5144162445e-01 4.2900000000e-09 8.5258152389e-01 4.3300000000e-09 9.4560623102e-01 4.3700000000e-09 1.0321165360e+00 4.4100000000e-09 1.1133974596e+00
+ 4.4500000000e-09 1.1904805415e+00 4.4900000000e-09 1.2000000000e+00 4.5300000000e-09 1.2000000000e+00
* Input Slew Index = 2.000000e-10, IPTR = 2.000000e-10, Output Load = 4.000000e-14 *************************************
 77 4.0100000000e-09 5.0000000000e-12 2.0000000000e-10 4.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0500000000e-09 6.0000000000e-02 4.0900000000e-09 2.1774457168e-01 4.1300000000e-09 3.7681869307e-01 4.1700000000e-09 5.1634960800e-01 4.2100000000e-09 6.4019237886e-01
+ 4.2500000000e-09 7.5144162445e-01 4.2900000000e-09 8.5258152389e-01 4.3300000000e-09 9.4560623102e-01 4.3700000000e-09 1.0321165360e+00 4.4100000000e-09 1.1133974596e+00
+ 4.4500000000e-09 1.1904805415e+00 4.4900000000e-09 1.2000000000e+00 4.5300000000e-09 1.2000000000e+00
* Input Slew Index = 2.000000e-10, IPTR = 2.000000e-10, Output Load = 4.200000e-14 *************************************
 78 4.0100000000e-09 5.0000000000e-12 2.0000000000e-10 4.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0500000000e-09 6.0000000000e-02 4.0900000000e-09 2.1774457168e-01 4.1300000000e-09 3.7681869307e-01 4.1700000000e-09 5.1634960800e-01 4.2100000000e-09 6.4019237886e-01
+ 4.2500000000e-09 7.5144162445e-01 4.2900000000e-09 8.5258152389e-01 4.3300000000e-09 9.4560623102e-01 4.3700000000e-09 1.0321165360e+00 4.4100000000e-09 1.1133974596e+00
+ 4.4500000000e-09 1.1904805415e+00 4.4900000000e-09 1.2000000000e+00 4.5300000000e-09 1.2000000000e+00
* Input Slew Index= 4.0000000000e-10 (IPTR = 4.0000000000e-10) ======================================================================
* Waveform to Side Pin A (Full swing = 1.000000e-11):
* 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00
* Stimlus to RelatedInPin B (Slew Index = 4.000000e-10, Slew = 4.000000e-10, Full swing = 8.000000e-10):
* 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00 4.0900000000e-09 6.0000000000e-02 4.1700000000e-09 2.1774457168e-01
* 4.2500000000e-09 3.7681869307e-01 4.3300000000e-09 5.1634960800e-01 4.4100000000e-09 6.4019237886e-01 4.4900000000e-09 7.5144162445e-01 4.5700000000e-09 8.5258152389e-01
* 4.6500000000e-09 9.4560623102e-01 4.7300000000e-09 1.0321165360e+00 4.8100000000e-09 1.1133974596e+00 4.8900000000e-09 1.1904805415e+00 4.9700000000e-09 1.2000000000e+00
* 5.0500000000e-09 1.2000000000e+00
* Input Slew Index = 4.000000e-10, IPTR = 4.000000e-10, Output Load = 6.000000e-15 *************************************
 79 4.0100000000e-09 5.0000000000e-12 4.0000000000e-10 6.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0900000000e-09 6.0000000000e-02 4.1700000000e-09 2.1774457168e-01 4.2500000000e-09 3.7681869307e-01 4.3300000000e-09 5.1634960800e-01 4.4100000000e-09 6.4019237886e-01
+ 4.4900000000e-09 7.5144162445e-01 4.5700000000e-09 8.5258152389e-01 4.6500000000e-09 9.4560623102e-01 4.7300000000e-09 1.0321165360e+00 4.8100000000e-09 1.1133974596e+00
+ 4.8900000000e-09 1.1904805415e+00 4.9700000000e-09 1.2000000000e+00 5.0500000000e-09 1.2000000000e+00
* Input Slew Index = 4.000000e-10, IPTR = 4.000000e-10, Output Load = 9.000000e-15 *************************************
 80 4.0100000000e-09 5.0000000000e-12 4.0000000000e-10 9.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0900000000e-09 6.0000000000e-02 4.1700000000e-09 2.1774457168e-01 4.2500000000e-09 3.7681869307e-01 4.3300000000e-09 5.1634960800e-01 4.4100000000e-09 6.4019237886e-01
+ 4.4900000000e-09 7.5144162445e-01 4.5700000000e-09 8.5258152389e-01 4.6500000000e-09 9.4560623102e-01 4.7300000000e-09 1.0321165360e+00 4.8100000000e-09 1.1133974596e+00
+ 4.8900000000e-09 1.1904805415e+00 4.9700000000e-09 1.2000000000e+00 5.0500000000e-09 1.2000000000e+00
* Input Slew Index = 4.000000e-10, IPTR = 4.000000e-10, Output Load = 1.200000e-14 *************************************
 81 4.0100000000e-09 5.0000000000e-12 4.0000000000e-10 1.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0900000000e-09 6.0000000000e-02 4.1700000000e-09 2.1774457168e-01 4.2500000000e-09 3.7681869307e-01 4.3300000000e-09 5.1634960800e-01 4.4100000000e-09 6.4019237886e-01
+ 4.4900000000e-09 7.5144162445e-01 4.5700000000e-09 8.5258152389e-01 4.6500000000e-09 9.4560623102e-01 4.7300000000e-09 1.0321165360e+00 4.8100000000e-09 1.1133974596e+00
+ 4.8900000000e-09 1.1904805415e+00 4.9700000000e-09 1.2000000000e+00 5.0500000000e-09 1.2000000000e+00
* Input Slew Index = 4.000000e-10, IPTR = 4.000000e-10, Output Load = 1.500000e-14 *************************************
 82 4.0100000000e-09 5.0000000000e-12 4.0000000000e-10 1.5000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0900000000e-09 6.0000000000e-02 4.1700000000e-09 2.1774457168e-01 4.2500000000e-09 3.7681869307e-01 4.3300000000e-09 5.1634960800e-01 4.4100000000e-09 6.4019237886e-01
+ 4.4900000000e-09 7.5144162445e-01 4.5700000000e-09 8.5258152389e-01 4.6500000000e-09 9.4560623102e-01 4.7300000000e-09 1.0321165360e+00 4.8100000000e-09 1.1133974596e+00
+ 4.8900000000e-09 1.1904805415e+00 4.9700000000e-09 1.2000000000e+00 5.0500000000e-09 1.2000000000e+00
* Input Slew Index = 4.000000e-10, IPTR = 4.000000e-10, Output Load = 1.800000e-14 *************************************
 83 4.0100000000e-09 5.0000000000e-12 4.0000000000e-10 1.8000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0900000000e-09 6.0000000000e-02 4.1700000000e-09 2.1774457168e-01 4.2500000000e-09 3.7681869307e-01 4.3300000000e-09 5.1634960800e-01 4.4100000000e-09 6.4019237886e-01
+ 4.4900000000e-09 7.5144162445e-01 4.5700000000e-09 8.5258152389e-01 4.6500000000e-09 9.4560623102e-01 4.7300000000e-09 1.0321165360e+00 4.8100000000e-09 1.1133974596e+00
+ 4.8900000000e-09 1.1904805415e+00 4.9700000000e-09 1.2000000000e+00 5.0500000000e-09 1.2000000000e+00
* Input Slew Index = 4.000000e-10, IPTR = 4.000000e-10, Output Load = 2.100000e-14 *************************************
 84 4.0100000000e-09 5.0000000000e-12 4.0000000000e-10 2.1000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0900000000e-09 6.0000000000e-02 4.1700000000e-09 2.1774457168e-01 4.2500000000e-09 3.7681869307e-01 4.3300000000e-09 5.1634960800e-01 4.4100000000e-09 6.4019237886e-01
+ 4.4900000000e-09 7.5144162445e-01 4.5700000000e-09 8.5258152389e-01 4.6500000000e-09 9.4560623102e-01 4.7300000000e-09 1.0321165360e+00 4.8100000000e-09 1.1133974596e+00
+ 4.8900000000e-09 1.1904805415e+00 4.9700000000e-09 1.2000000000e+00 5.0500000000e-09 1.2000000000e+00
* Input Slew Index = 4.000000e-10, IPTR = 4.000000e-10, Output Load = 2.400000e-14 *************************************
 85 4.0100000000e-09 5.0000000000e-12 4.0000000000e-10 2.4000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0900000000e-09 6.0000000000e-02 4.1700000000e-09 2.1774457168e-01 4.2500000000e-09 3.7681869307e-01 4.3300000000e-09 5.1634960800e-01 4.4100000000e-09 6.4019237886e-01
+ 4.4900000000e-09 7.5144162445e-01 4.5700000000e-09 8.5258152389e-01 4.6500000000e-09 9.4560623102e-01 4.7300000000e-09 1.0321165360e+00 4.8100000000e-09 1.1133974596e+00
+ 4.8900000000e-09 1.1904805415e+00 4.9700000000e-09 1.2000000000e+00 5.0500000000e-09 1.2000000000e+00
* Input Slew Index = 4.000000e-10, IPTR = 4.000000e-10, Output Load = 2.700000e-14 *************************************
 86 4.0100000000e-09 5.0000000000e-12 4.0000000000e-10 2.7000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0900000000e-09 6.0000000000e-02 4.1700000000e-09 2.1774457168e-01 4.2500000000e-09 3.7681869307e-01 4.3300000000e-09 5.1634960800e-01 4.4100000000e-09 6.4019237886e-01
+ 4.4900000000e-09 7.5144162445e-01 4.5700000000e-09 8.5258152389e-01 4.6500000000e-09 9.4560623102e-01 4.7300000000e-09 1.0321165360e+00 4.8100000000e-09 1.1133974596e+00
+ 4.8900000000e-09 1.1904805415e+00 4.9700000000e-09 1.2000000000e+00 5.0500000000e-09 1.2000000000e+00
* Input Slew Index = 4.000000e-10, IPTR = 4.000000e-10, Output Load = 3.000000e-14 *************************************
 87 4.0100000000e-09 5.0000000000e-12 4.0000000000e-10 3.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0900000000e-09 6.0000000000e-02 4.1700000000e-09 2.1774457168e-01 4.2500000000e-09 3.7681869307e-01 4.3300000000e-09 5.1634960800e-01 4.4100000000e-09 6.4019237886e-01
+ 4.4900000000e-09 7.5144162445e-01 4.5700000000e-09 8.5258152389e-01 4.6500000000e-09 9.4560623102e-01 4.7300000000e-09 1.0321165360e+00 4.8100000000e-09 1.1133974596e+00
+ 4.8900000000e-09 1.1904805415e+00 4.9700000000e-09 1.2000000000e+00 5.0500000000e-09 1.2000000000e+00
* Input Slew Index = 4.000000e-10, IPTR = 4.000000e-10, Output Load = 3.300000e-14 *************************************
 88 4.0100000000e-09 5.0000000000e-12 4.0000000000e-10 3.3000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0900000000e-09 6.0000000000e-02 4.1700000000e-09 2.1774457168e-01 4.2500000000e-09 3.7681869307e-01 4.3300000000e-09 5.1634960800e-01 4.4100000000e-09 6.4019237886e-01
+ 4.4900000000e-09 7.5144162445e-01 4.5700000000e-09 8.5258152389e-01 4.6500000000e-09 9.4560623102e-01 4.7300000000e-09 1.0321165360e+00 4.8100000000e-09 1.1133974596e+00
+ 4.8900000000e-09 1.1904805415e+00 4.9700000000e-09 1.2000000000e+00 5.0500000000e-09 1.2000000000e+00
* Input Slew Index = 4.000000e-10, IPTR = 4.000000e-10, Output Load = 3.600000e-14 *************************************
 89 4.0100000000e-09 5.0000000000e-12 4.0000000000e-10 3.6000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0900000000e-09 6.0000000000e-02 4.1700000000e-09 2.1774457168e-01 4.2500000000e-09 3.7681869307e-01 4.3300000000e-09 5.1634960800e-01 4.4100000000e-09 6.4019237886e-01
+ 4.4900000000e-09 7.5144162445e-01 4.5700000000e-09 8.5258152389e-01 4.6500000000e-09 9.4560623102e-01 4.7300000000e-09 1.0321165360e+00 4.8100000000e-09 1.1133974596e+00
+ 4.8900000000e-09 1.1904805415e+00 4.9700000000e-09 1.2000000000e+00 5.0500000000e-09 1.2000000000e+00
* Input Slew Index = 4.000000e-10, IPTR = 4.000000e-10, Output Load = 4.000000e-14 *************************************
 90 4.0100000000e-09 5.0000000000e-12 4.0000000000e-10 4.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0900000000e-09 6.0000000000e-02 4.1700000000e-09 2.1774457168e-01 4.2500000000e-09 3.7681869307e-01 4.3300000000e-09 5.1634960800e-01 4.4100000000e-09 6.4019237886e-01
+ 4.4900000000e-09 7.5144162445e-01 4.5700000000e-09 8.5258152389e-01 4.6500000000e-09 9.4560623102e-01 4.7300000000e-09 1.0321165360e+00 4.8100000000e-09 1.1133974596e+00
+ 4.8900000000e-09 1.1904805415e+00 4.9700000000e-09 1.2000000000e+00 5.0500000000e-09 1.2000000000e+00
* Input Slew Index = 4.000000e-10, IPTR = 4.000000e-10, Output Load = 4.200000e-14 *************************************
 91 4.0100000000e-09 5.0000000000e-12 4.0000000000e-10 4.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.0900000000e-09 6.0000000000e-02 4.1700000000e-09 2.1774457168e-01 4.2500000000e-09 3.7681869307e-01 4.3300000000e-09 5.1634960800e-01 4.4100000000e-09 6.4019237886e-01
+ 4.4900000000e-09 7.5144162445e-01 4.5700000000e-09 8.5258152389e-01 4.6500000000e-09 9.4560623102e-01 4.7300000000e-09 1.0321165360e+00 4.8100000000e-09 1.1133974596e+00
+ 4.8900000000e-09 1.1904805415e+00 4.9700000000e-09 1.2000000000e+00 5.0500000000e-09 1.2000000000e+00
* Input Slew Index= 8.0000000000e-10 (IPTR = 8.0000000000e-10) ======================================================================
* Waveform to Side Pin A (Full swing = 1.000000e-11):
* 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00
* Stimlus to RelatedInPin B (Slew Index = 8.000000e-10, Slew = 8.000000e-10, Full swing = 1.600000e-09):
* 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00 4.1700000000e-09 6.0000000000e-02 4.3300000000e-09 2.1774457168e-01
* 4.4900000000e-09 3.7681869307e-01 4.6500000000e-09 5.1634960800e-01 4.8100000000e-09 6.4019237886e-01 4.9700000000e-09 7.5144162445e-01 5.1300000000e-09 8.5258152389e-01
* 5.2900000000e-09 9.4560623102e-01 5.4500000000e-09 1.0321165360e+00 5.6100000000e-09 1.1133974596e+00 5.7700000000e-09 1.1904805415e+00 5.9300000000e-09 1.2000000000e+00
* 6.0900000000e-09 1.2000000000e+00
* Input Slew Index = 8.000000e-10, IPTR = 8.000000e-10, Output Load = 6.000000e-15 *************************************
 92 4.0100000000e-09 5.0000000000e-12 8.0000000000e-10 6.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.1700000000e-09 6.0000000000e-02 4.3300000000e-09 2.1774457168e-01 4.4900000000e-09 3.7681869307e-01 4.6500000000e-09 5.1634960800e-01 4.8100000000e-09 6.4019237886e-01
+ 4.9700000000e-09 7.5144162445e-01 5.1300000000e-09 8.5258152389e-01 5.2900000000e-09 9.4560623102e-01 5.4500000000e-09 1.0321165360e+00 5.6100000000e-09 1.1133974596e+00
+ 5.7700000000e-09 1.1904805415e+00 5.9300000000e-09 1.2000000000e+00 6.0900000000e-09 1.2000000000e+00
* Input Slew Index = 8.000000e-10, IPTR = 8.000000e-10, Output Load = 9.000000e-15 *************************************
 93 4.0100000000e-09 5.0000000000e-12 8.0000000000e-10 9.0000000000e-15
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.1700000000e-09 6.0000000000e-02 4.3300000000e-09 2.1774457168e-01 4.4900000000e-09 3.7681869307e-01 4.6500000000e-09 5.1634960800e-01 4.8100000000e-09 6.4019237886e-01
+ 4.9700000000e-09 7.5144162445e-01 5.1300000000e-09 8.5258152389e-01 5.2900000000e-09 9.4560623102e-01 5.4500000000e-09 1.0321165360e+00 5.6100000000e-09 1.1133974596e+00
+ 5.7700000000e-09 1.1904805415e+00 5.9300000000e-09 1.2000000000e+00 6.0900000000e-09 1.2000000000e+00
* Input Slew Index = 8.000000e-10, IPTR = 8.000000e-10, Output Load = 1.200000e-14 *************************************
 94 4.0100000000e-09 5.0000000000e-12 8.0000000000e-10 1.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.1700000000e-09 6.0000000000e-02 4.3300000000e-09 2.1774457168e-01 4.4900000000e-09 3.7681869307e-01 4.6500000000e-09 5.1634960800e-01 4.8100000000e-09 6.4019237886e-01
+ 4.9700000000e-09 7.5144162445e-01 5.1300000000e-09 8.5258152389e-01 5.2900000000e-09 9.4560623102e-01 5.4500000000e-09 1.0321165360e+00 5.6100000000e-09 1.1133974596e+00
+ 5.7700000000e-09 1.1904805415e+00 5.9300000000e-09 1.2000000000e+00 6.0900000000e-09 1.2000000000e+00
* Input Slew Index = 8.000000e-10, IPTR = 8.000000e-10, Output Load = 1.500000e-14 *************************************
 95 4.0100000000e-09 5.0000000000e-12 8.0000000000e-10 1.5000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.1700000000e-09 6.0000000000e-02 4.3300000000e-09 2.1774457168e-01 4.4900000000e-09 3.7681869307e-01 4.6500000000e-09 5.1634960800e-01 4.8100000000e-09 6.4019237886e-01
+ 4.9700000000e-09 7.5144162445e-01 5.1300000000e-09 8.5258152389e-01 5.2900000000e-09 9.4560623102e-01 5.4500000000e-09 1.0321165360e+00 5.6100000000e-09 1.1133974596e+00
+ 5.7700000000e-09 1.1904805415e+00 5.9300000000e-09 1.2000000000e+00 6.0900000000e-09 1.2000000000e+00
* Input Slew Index = 8.000000e-10, IPTR = 8.000000e-10, Output Load = 1.800000e-14 *************************************
 96 4.0100000000e-09 5.0000000000e-12 8.0000000000e-10 1.8000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.1700000000e-09 6.0000000000e-02 4.3300000000e-09 2.1774457168e-01 4.4900000000e-09 3.7681869307e-01 4.6500000000e-09 5.1634960800e-01 4.8100000000e-09 6.4019237886e-01
+ 4.9700000000e-09 7.5144162445e-01 5.1300000000e-09 8.5258152389e-01 5.2900000000e-09 9.4560623102e-01 5.4500000000e-09 1.0321165360e+00 5.6100000000e-09 1.1133974596e+00
+ 5.7700000000e-09 1.1904805415e+00 5.9300000000e-09 1.2000000000e+00 6.0900000000e-09 1.2000000000e+00
* Input Slew Index = 8.000000e-10, IPTR = 8.000000e-10, Output Load = 2.100000e-14 *************************************
 97 4.0100000000e-09 5.0000000000e-12 8.0000000000e-10 2.1000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.1700000000e-09 6.0000000000e-02 4.3300000000e-09 2.1774457168e-01 4.4900000000e-09 3.7681869307e-01 4.6500000000e-09 5.1634960800e-01 4.8100000000e-09 6.4019237886e-01
+ 4.9700000000e-09 7.5144162445e-01 5.1300000000e-09 8.5258152389e-01 5.2900000000e-09 9.4560623102e-01 5.4500000000e-09 1.0321165360e+00 5.6100000000e-09 1.1133974596e+00
+ 5.7700000000e-09 1.1904805415e+00 5.9300000000e-09 1.2000000000e+00 6.0900000000e-09 1.2000000000e+00
* Input Slew Index = 8.000000e-10, IPTR = 8.000000e-10, Output Load = 2.400000e-14 *************************************
 98 4.0100000000e-09 5.0000000000e-12 8.0000000000e-10 2.4000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.1700000000e-09 6.0000000000e-02 4.3300000000e-09 2.1774457168e-01 4.4900000000e-09 3.7681869307e-01 4.6500000000e-09 5.1634960800e-01 4.8100000000e-09 6.4019237886e-01
+ 4.9700000000e-09 7.5144162445e-01 5.1300000000e-09 8.5258152389e-01 5.2900000000e-09 9.4560623102e-01 5.4500000000e-09 1.0321165360e+00 5.6100000000e-09 1.1133974596e+00
+ 5.7700000000e-09 1.1904805415e+00 5.9300000000e-09 1.2000000000e+00 6.0900000000e-09 1.2000000000e+00
* Input Slew Index = 8.000000e-10, IPTR = 8.000000e-10, Output Load = 2.700000e-14 *************************************
 99 4.0100000000e-09 5.0000000000e-12 8.0000000000e-10 2.7000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.1700000000e-09 6.0000000000e-02 4.3300000000e-09 2.1774457168e-01 4.4900000000e-09 3.7681869307e-01 4.6500000000e-09 5.1634960800e-01 4.8100000000e-09 6.4019237886e-01
+ 4.9700000000e-09 7.5144162445e-01 5.1300000000e-09 8.5258152389e-01 5.2900000000e-09 9.4560623102e-01 5.4500000000e-09 1.0321165360e+00 5.6100000000e-09 1.1133974596e+00
+ 5.7700000000e-09 1.1904805415e+00 5.9300000000e-09 1.2000000000e+00 6.0900000000e-09 1.2000000000e+00
* Input Slew Index = 8.000000e-10, IPTR = 8.000000e-10, Output Load = 3.000000e-14 *************************************
100 4.0100000000e-09 5.0000000000e-12 8.0000000000e-10 3.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.1700000000e-09 6.0000000000e-02 4.3300000000e-09 2.1774457168e-01 4.4900000000e-09 3.7681869307e-01 4.6500000000e-09 5.1634960800e-01 4.8100000000e-09 6.4019237886e-01
+ 4.9700000000e-09 7.5144162445e-01 5.1300000000e-09 8.5258152389e-01 5.2900000000e-09 9.4560623102e-01 5.4500000000e-09 1.0321165360e+00 5.6100000000e-09 1.1133974596e+00
+ 5.7700000000e-09 1.1904805415e+00 5.9300000000e-09 1.2000000000e+00 6.0900000000e-09 1.2000000000e+00
* Input Slew Index = 8.000000e-10, IPTR = 8.000000e-10, Output Load = 3.300000e-14 *************************************
101 4.0100000000e-09 5.0000000000e-12 8.0000000000e-10 3.3000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.1700000000e-09 6.0000000000e-02 4.3300000000e-09 2.1774457168e-01 4.4900000000e-09 3.7681869307e-01 4.6500000000e-09 5.1634960800e-01 4.8100000000e-09 6.4019237886e-01
+ 4.9700000000e-09 7.5144162445e-01 5.1300000000e-09 8.5258152389e-01 5.2900000000e-09 9.4560623102e-01 5.4500000000e-09 1.0321165360e+00 5.6100000000e-09 1.1133974596e+00
+ 5.7700000000e-09 1.1904805415e+00 5.9300000000e-09 1.2000000000e+00 6.0900000000e-09 1.2000000000e+00
* Input Slew Index = 8.000000e-10, IPTR = 8.000000e-10, Output Load = 3.600000e-14 *************************************
102 4.0100000000e-09 5.0000000000e-12 8.0000000000e-10 3.6000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.1700000000e-09 6.0000000000e-02 4.3300000000e-09 2.1774457168e-01 4.4900000000e-09 3.7681869307e-01 4.6500000000e-09 5.1634960800e-01 4.8100000000e-09 6.4019237886e-01
+ 4.9700000000e-09 7.5144162445e-01 5.1300000000e-09 8.5258152389e-01 5.2900000000e-09 9.4560623102e-01 5.4500000000e-09 1.0321165360e+00 5.6100000000e-09 1.1133974596e+00
+ 5.7700000000e-09 1.1904805415e+00 5.9300000000e-09 1.2000000000e+00 6.0900000000e-09 1.2000000000e+00
* Input Slew Index = 8.000000e-10, IPTR = 8.000000e-10, Output Load = 4.000000e-14 *************************************
103 4.0100000000e-09 5.0000000000e-12 8.0000000000e-10 4.0000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.1700000000e-09 6.0000000000e-02 4.3300000000e-09 2.1774457168e-01 4.4900000000e-09 3.7681869307e-01 4.6500000000e-09 5.1634960800e-01 4.8100000000e-09 6.4019237886e-01
+ 4.9700000000e-09 7.5144162445e-01 5.1300000000e-09 8.5258152389e-01 5.2900000000e-09 9.4560623102e-01 5.4500000000e-09 1.0321165360e+00 5.6100000000e-09 1.1133974596e+00
+ 5.7700000000e-09 1.1904805415e+00 5.9300000000e-09 1.2000000000e+00 6.0900000000e-09 1.2000000000e+00
* Input Slew Index = 8.000000e-10, IPTR = 8.000000e-10, Output Load = 4.200000e-14 *************************************
104 4.0100000000e-09 5.0000000000e-12 8.0000000000e-10 4.2000000000e-14
+ 0.0000000000e+00 1.2000000000e+00 4.0000000000e-07 1.2000000000e+00 0.0000000000e+00 0.0000000000e+00 4.0000000000e-09 0.0000000000e+00 4.0100000000e-09 0.0000000000e+00
+ 4.1700000000e-09 6.0000000000e-02 4.3300000000e-09 2.1774457168e-01 4.4900000000e-09 3.7681869307e-01 4.6500000000e-09 5.1634960800e-01 4.8100000000e-09 6.4019237886e-01
+ 4.9700000000e-09 7.5144162445e-01 5.1300000000e-09 8.5258152389e-01 5.2900000000e-09 9.4560623102e-01 5.4500000000e-09 1.0321165360e+00 5.6100000000e-09 1.1133974596e+00
+ 5.7700000000e-09 1.1904805415e+00 5.9300000000e-09 1.2000000000e+00 6.0900000000e-09 1.2000000000e+00
.ENDDATA

* for Input Pin A
Vn_A2 n_A2 0 PWL(
+'t_A0' 'v_A0'
+'t_A1' 'v_A1'
+)
* for Input Pin B
Vn_B2 n_B2 0 PWL(
+'t_B0' 'v_B0'
+'t_B1' 'v_B1'
+'t_B2' 'v_B2'
+'t_B3' 'v_B3'
+'t_B4' 'v_B4'
+'t_B5' 'v_B5'
+'t_B6' 'v_B6'
+'t_B7' 'v_B7'
+'t_B8' 'v_B8'
+'t_B9' 'v_B9'
+'t_B10' 'v_B10'
+'t_B11' 'v_B11'
+'t_B12' 'v_B12'
+'t_B13' 'v_B13'
+'t_B14' 'v_B14'
+'t_B15' 'v_B15'
+)

* .TRAN ==========================
.TRAN 1.0000000000e-10 4.8000000000e-08 START = 0.0 sweep data=stimdata
* InPin A PWL length=2 Sens=1
* InPin B PWL length=16 Sens=01

* MEASUREMENT ==========================

* Measure Gate Delay
.MEASURE TRAN nc_delay_B_Out
* input is rising: vL=0.000000e+00, vH=1.200000e+00
+ trig V(n_B) val = 6.0000000000e-01 td = 'nc_td' cross = 1
* output is rising: vL=0.000000e+00, vH=1.200000e+00
+ targ V(n_Out) val = 6.0000000000e-01 td = 'nc_td' cross = 1

* Measure Input Reference Time
.MEASURE nc_inref_B WHEN V(n_B) = 6.0000000000e-01 td = 'nc_td' cross = 1
* input is rising

* Measure Gate Output Transition Time
.MEASURE TRAN nc_optr_Out
+ trig V(n_Out) val = 3.0000000000e-01 td = 'nc_td' cross = 1
+ targ V(n_Out) val = 9.0000000000e-01 td = 'nc_td' cross = 1

* Measure Full Swing Output Transition Time (0.5% to 99.5%)
.MEASURE TRAN nc_fulloptr_Out
+ trig V(n_Out) val = 6.0000000000e-03 td = 'nc_td' cross = 1
+ targ V(n_Out) val = 1.1940000000e+00 td = 'nc_td' cross = 1

* Measure Input Trip Points
.MEASURE t_B_trip1 WHEN V(n_B) = 3.0000000000e-01 td = 'nc_td' cross = 1
.MEASURE t_B_trip2 WHEN V(n_B) = 9.0000000000e-01 td = 'nc_td' cross = 1

* Measure Input End Points(Rise)
.MEASURE t_stop_B WHEN V(n_B) = 1.1400000000e+00 td = 'nc_td' cross = 1

* Simulation Stop time with AutoSTOP
.MEASURE t_stop_Out WHEN V(n_Out) = 1.1940000000e+00 td = 'nc_td' cross = 1
.MEASURE t_simstop PARAM = 'max(t_stop_Out, t_stop_B)'

* Measure Input Capacitance
.MEASURE t_B_trip_incap1 WHEN V(n_B) = 6.0000000000e-03 td = 'nc_td' cross = 1
.MEASURE t_B_trip_incap2 WHEN V(n_B) = 9.0000000000e-01 td = 'nc_td' cross = 1
.MEASURE TRAN nc_intg_i_B INTEG I(Vn_B) FROM = 't_B_trip_incap1' TO = 't_B_trip_incap2'
.MEASURE TRAN nc_intg_i1_B INTEG I(Vn_B) FROM = 't_B_trip_incap1' TO = 'nc_inref_B'
.MEASURE TRAN nc_intg_i2_B INTEG I(Vn_B) FROM = 'nc_inref_B' TO = 't_B_trip_incap2'
.MEASURE TRAN nc_incap_B param='ABS(nc_intg_i_B/8.9400000000e-01)'
.MEASURE TRAN nc_incap_c1_B param='ABS(nc_intg_i1_B/5.9400000000e-01)'
.MEASURE TRAN nc_incap_c2_B param='ABS(nc_intg_i2_B/3.0000000000e-01)'

* Measure Input Transition Time
.MEASURE TRAN nc_iptr_B PARAM = 'iptr'
.MEASURE TRAN real_iptr_B
+ trig V(n_B) val = 3.0000000000e-01 td = 'nc_td' cross = 1
+ targ V(n_B) val = 9.0000000000e-01 td = 'nc_td' cross = 1
.MEASURE TRAN nc_when_A param = '1'
.MEASURE TRAN nc_when_B param = '1'
.MEASURE TRAN nc_when_Out param = '1'

* Measure Leakage Currents
.MEASURE TRAN nc_leak_i_A AVG I(Vn_A) FROM = 't_B0' TO = 't_B1'
.MEASURE TRAN nc_leak_i_B AVG I(Vn_B) FROM = 't_B0' TO = 't_B1'
.MEASURE TRAN nc_leak_i_VSS AVG I(Vn_VSS) FROM = 't_B0' TO = 't_B1'
.MEASURE TRAN nc_leak_i_Vdd AVG I(Vn_Vdd) FROM = 't_B0' TO = 't_B1'

* Measure Dynamic Energy
.MEASURE TRAN nc_dyn_energy INTEG par(' -(I(Vn_VSS)*V(VSS)) -(I(Vn_Vdd)*V(Vdd))') From= 'nc_td' TO = 't_simstop'

* Energy Integral period
.MEASURE TRAN t_int_energy PARAM = 't_simstop - nc_td'

* Measure Internal Energy
.MEASURE TRAN nc_int_energy PARAM = 'nc_dyn_energy -cap_Out*1.200000e+00*1.200000e+00'

* Measure Dynamic Energy in Power Supply
.MEASURE TRAN nc_dyn_eng_VSS INTEG par(' -(I(Vn_VSS)*V(VSS))') From= 'nc_td' TO = 't_simstop'
.MEASURE TRAN nc_dyn_eng_Vdd INTEG par(' -(I(Vn_Vdd)*V(Vdd))') From= 'nc_td' TO = 't_simstop'

* Measure Dynamic ABS Energy
.MEASURE TRAN nc_dyn_abs_energy INTEG par(' +ABS(I(Vn_VSS)*V(VSS)) +ABS(I(Vn_Vdd)*V(Vdd))') From= 'nc_td' TO = 't_simstop'

* Measure total charge
.MEASURE TRAN nc_charge_VSS INTEG I(Vn_VSS) From= 'nc_td' TO = 't_simstop'
.MEASURE TRAN nc_charge_Vdd INTEG I(Vn_Vdd) From= 'nc_td' TO = 't_simstop'

* Load for Side Output pin
.MEASURE TRAN nc_sidecap PARAM = 'SideCap'

.END
